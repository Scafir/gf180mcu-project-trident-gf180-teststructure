v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
T {klayout does not seem to support multiple pins to the same net. Hence, there are empty lines where a duplicated pin should be (e.g VDD, VSS)} 7480 -120 0 0 0.4 0.4 {}
T {VDD} 7870 -390 0 0 0.4 0.4 {}
T {VSS} 7870 -830 0 0 0.4 0.4 {}
T {VDD} 7950 -7440 0 0 0.4 0.4 {}
T {VSS} 7950 -7880 0 0 0.4 0.4 {}
T {VDD} 2020 -7860 2 0 0.4 0.4 {}
T {VSS} 2020 -7420 2 0 0.4 0.4 {}
T {guard_transistors_pad} 7870 -6990 0 0 0.4 0.4 {}
T {VDD} 7950 -17120 0 0 0.4 0.4 {}
T {VSS} 7950 -17560 0 0 0.4 0.4 {}
T {VDD} 2040 -17560 2 0 0.4 0.4 {}
T {VSS} 2040 -17120 2 0 0.4 0.4 {}
T {21} 3420 -18740 3 1 0.4 0.4 {}
T {22} 3870 -18780 3 1 0.4 0.4 {}
T {23} 4740 -18730 3 1 0.4 0.4 {}
T {24} 4790 -18870 3 1 0.4 0.4 {}
T {25} 4880 -18680 3 1 0.4 0.4 {}
T {26} 5390 -18660 3 1 0.4 0.4 {}
T {27} 5730 -18670 3 1 0.4 0.4 {}
T {28} 6090 -18670 3 1 0.4 0.4 {}
T {29} 6390 -18670 3 1 0.4 0.4 {}
T {30} 7070 -18660 0 1 0.4 0.4 {}
T {31} 8290 -17530 0 1 0.4 0.4 {}
T {32} 8320 -17100 0 1 0.4 0.4 {}
T {33} 8300 -16640 0 1 0.4 0.4 {}
T {34} 8330 -16210 0 1 0.4 0.4 {}
T {35
} 8310 -15750 0 1 0.4 0.4 {}
T {36} 8290 -15340 0 1 0.4 0.4 {}
T {37} 8310 -14890 0 1 0.4 0.4 {}
T {38} 8300 -14460 0 1 0.4 0.4 {}
T {39} 8330 -14020 0 1 0.4 0.4 {}
T {40} 8330 -13550 0 1 0.4 0.4 {}
T {1} 1610 -9220 0 0 0.4 0.4 {}
T {2} 1610 -9650 0 0 0.4 0.4 {}
T {3} 1610 -10090 0 0 0.4 0.4 {}
T {4} 1630 -10540 0 0 0.4 0.4 {}
T {5} 1640 -10980 0 0 0.4 0.4 {}
T {6} 1640 -11410 0 0 0.4 0.4 {}
T {7} 1650 -11860 0 0 0.4 0.4 {}
T {8} 1660 -12290 0 0 0.4 0.4 {}
T {9} 1660 -12740 0 0 0.4 0.4 {}
T {10} 1670 -13170 0 0 0.4 0.4 {}
T {11} 1690 -13620 0 0 0.4 0.4 {}
T {12} 1720 -14060 0 0 0.4 0.4 {}
T {13} 1740 -14490 0 0 0.4 0.4 {}
T {14} 1750 -14930 0 0 0.4 0.4 {}
T {15} 1770 -15370 0 0 0.4 0.4 {}
T {16} 1780 -15830 0 0 0.4 0.4 {}
T {17} 1800 -16250 0 0 0.4 0.4 {}
T {18} 1810 -16690 0 0 0.4 0.4 {}
T {19} 1820 -17150 0 0 0.4 0.4 {}
T {20} 1830 -17590 0 0 0.4 0.4 {}
T {NO BOND} 4820 -18870 0 0 0.4 0.4 {}
T {NO BOND} 5430 -18670 0 0 0.4 0.4 {}
T {NO BOND} 6120 -18670 0 0 0.4 0.4 {}
T {41} 8300 -13160 0 1 0.4 0.4 {}
T {42} 8360 -12720 0 1 0.4 0.4 {}
T {43} 8380 -12280 0 1 0.4 0.4 {}
T {44} 8390 -11840 0 1 0.4 0.4 {}
T {45} 8370 -11390 0 1 0.4 0.4 {}
T {46} 8400 -10940 0 1 0.4 0.4 {}
T {47} 8410 -10520 0 1 0.4 0.4 {}
T {48} 8410 -10080 0 1 0.4 0.4 {}
T {49} 8410 -9640 0 1 0.4 0.4 {}
T {50} 8420 -9190 0 1 0.4 0.4 {}
T {51} 8420 -8740 0 1 0.4 0.4 {}
T {52} 8430 -8300 0 1 0.4 0.4 {}
T {53} 8410 -7890 0 1 0.4 0.4 {}
T {54} 8400 -7420 0 1 0.4 0.4 {}
T {55} 8400 -6990 0 1 0.4 0.4 {}
T {56} 8400 -6540 0 1 0.4 0.4 {}
T {57} 8410 -6100 0 1 0.4 0.4 {}
T {58} 8410 -5660 0 1 0.4 0.4 {}
T {59} 8390 -5230 0 1 0.4 0.4 {}
T {60} 8400 -4790 0 1 0.4 0.4 {}
T {61} 8380 -4350 0 1 0.4 0.4 {}
T {62} 8360 -3910 0 1 0.4 0.4 {}
T {63} 8350 -3460 0 1 0.4 0.4 {}
T {64} 8330 -3030 0 1 0.4 0.4 {}
T {66} 8330 -2590 0 1 0.4 0.4 {}
T {66} 8330 -2150 0 1 0.4 0.4 {}
T {67} 8350 -1700 0 1 0.4 0.4 {}
T {68} 8330 -1270 0 1 0.4 0.4 {}
T {69} 8330 -830 0 1 0.4 0.4 {}
T {70} 8330 -390 0 1 0.4 0.4 {}
T {71} 7010 640 1 1 0.4 0.4 {}
T {72} 6390 620 1 1 0.4 0.4 {}
T {73} 5500 520 1 1 0.4 0.4 {}
T {74} 5450 640 1 1 0.4 0.4 {}
T {75} 5390 520 1 1 0.4 0.4 {}
T {76} 5050 470 1 1 0.4 0.4 {}
T {77} 4740 480 1 1 0.4 0.4 {}
T {78} 4410 480 1 1 0.4 0.4 {}
T {79} 4070 490 1 1 0.4 0.4 {}
T {80} 3630 480 1 1 0.4 0.4 {}
T {88} 1840 -3460 0 1 0.4 0.4 {}
T {87} 1820 -3030 0 1 0.4 0.4 {}
T {86} 1820 -2590 0 1 0.4 0.4 {}
T {85} 1820 -2150 0 1 0.4 0.4 {}
T {84} 1840 -1700 0 1 0.4 0.4 {}
T {83} 1820 -1270 0 1 0.4 0.4 {}
T {82} 1820 -830 0 1 0.4 0.4 {}
T {81} 1820 -390 0 1 0.4 0.4 {}
T {100} 1900 -8740 0 1 0.4 0.4 {}
T {99} 1880 -8310 0 1 0.4 0.4 {}
T {98} 1890 -7870 0 1 0.4 0.4 {}
T {97} 1870 -7430 0 1 0.4 0.4 {}
T {96} 1850 -6990 0 1 0.4 0.4 {}
T {95} 1840 -6540 0 1 0.4 0.4 {}
T {94} 1820 -6110 0 1 0.4 0.4 {}
T {93} 1820 -5670 0 1 0.4 0.4 {}
T {92} 1820 -5230 0 1 0.4 0.4 {}
T {91} 1840 -4780 0 1 0.4 0.4 {}
T {90} 1820 -4350 0 1 0.4 0.4 {}
T {89} 1820 -3910 0 1 0.4 0.4 {}
N 7640 -1630 7640 -1600 {lab=VDD}
N 7420 -1600 7640 -1600 {lab=VDD}
N 7600 -1630 7600 -1620 {lab=VDD}
N 7370 -1620 7600 -1620 {lab=VDD}
N 7640 -1800 7640 -1770 {lab=VSS}
N 7400 -1800 7640 -1800 {lab=VSS}
N 7350 -1780 7600 -1780 {lab=VSS}
N 7600 -1780 7600 -1770 {lab=VSS}
N 7780 -1700 7850 -1700 {lab=lv_nfet_W075L070_source_PAD}
N 7640 -1850 7640 -1820 {lab=VDD}
N 7420 -1820 7640 -1820 {lab=VDD}
N 7600 -1850 7600 -1840 {lab=VDD}
N 7370 -1840 7600 -1840 {lab=VDD}
N 7640 -2020 7640 -1990 {lab=VSS}
N 7400 -2020 7640 -2020 {lab=VSS}
N 7350 -2000 7600 -2000 {lab=VSS}
N 7600 -2000 7600 -1990 {lab=VSS}
N 7300 -1680 7480 -1680 {lab=guard_transistors_PAD}
N 7640 -2070 7640 -2040 {lab=VDD}
N 7420 -2040 7640 -2040 {lab=VDD}
N 7600 -2070 7600 -2060 {lab=VDD}
N 7370 -2060 7600 -2060 {lab=VDD}
N 7640 -2240 7640 -2210 {lab=VSS}
N 7400 -2240 7640 -2240 {lab=VSS}
N 7350 -2220 7600 -2220 {lab=VSS}
N 7600 -2220 7600 -2210 {lab=VSS}
N 7780 -2140 7850 -2140 {lab=lv_nfet_W075L070_gate_PAD}
N 7640 -2290 7640 -2260 {lab=VDD}
N 7420 -2260 7640 -2260 {lab=VDD}
N 7600 -2290 7600 -2280 {lab=VDD}
N 7370 -2280 7600 -2280 {lab=VDD}
N 7640 -2460 7640 -2430 {lab=VSS}
N 7400 -2460 7640 -2460 {lab=VSS}
N 7350 -2440 7600 -2440 {lab=VSS}
N 7600 -2440 7600 -2430 {lab=VSS}
N 7640 -2510 7640 -2480 {lab=VDD}
N 7420 -2480 7640 -2480 {lab=VDD}
N 7600 -2510 7600 -2500 {lab=VDD}
N 7370 -2500 7600 -2500 {lab=VDD}
N 7640 -2680 7640 -2650 {lab=VSS}
N 7400 -2680 7640 -2680 {lab=VSS}
N 7350 -2660 7600 -2660 {lab=VSS}
N 7600 -2660 7600 -2650 {lab=VSS}
N 7780 -2580 7850 -2580 {lab=lv_nfet_W075L070_drain_PAD}
N 7640 -2730 7640 -2700 {lab=VDD}
N 7420 -2700 7640 -2700 {lab=VDD}
N 7600 -2730 7600 -2720 {lab=VDD}
N 7370 -2720 7600 -2720 {lab=VDD}
N 7640 -2900 7640 -2870 {lab=VSS}
N 7400 -2900 7640 -2900 {lab=VSS}
N 7350 -2880 7600 -2880 {lab=VSS}
N 7600 -2880 7600 -2870 {lab=VSS}
N 7300 -2120 7480 -2120 {lab=guard_transistors_PAD}
N 7300 -2120 7300 -1680 {lab=guard_transistors_PAD}
N 7260 -2580 7480 -2580 {lab=lv_nfet_W075L070_drain_PAD}
N 7100 -2460 7100 -2400 {lab=guard_transistors_PAD}
N 7100 -2460 7300 -2460 {lab=guard_transistors_PAD}
N 7060 -2140 7480 -2140 {lab=lv_nfet_W075L070_gate_PAD}
N 7060 -2180 7060 -2140 {lab=lv_nfet_W075L070_gate_PAD}
N 7180 -1700 7480 -1700 {lab=lv_nfet_W075L070_source_PAD}
N 7180 -2180 7180 -1700 {lab=lv_nfet_W075L070_source_PAD}
N 7260 -2580 7260 -2160 {lab=lv_nfet_W075L070_drain_PAD}
N 7100 -2160 7260 -2160 {lab=lv_nfet_W075L070_drain_PAD}
N 7100 -2180 7100 -2160 {lab=lv_nfet_W075L070_drain_PAD}
N 7140 -2180 7140 -1940 {lab=VSS}
N 7140 -1940 7350 -1940 {lab=VSS}
N 7640 -2950 7640 -2920 {lab=VDD}
N 7420 -2920 7640 -2920 {lab=VDD}
N 7600 -2950 7600 -2940 {lab=VDD}
N 7370 -2940 7600 -2940 {lab=VDD}
N 7640 -3120 7640 -3090 {lab=VSS}
N 7400 -3120 7640 -3120 {lab=VSS}
N 7350 -3100 7600 -3100 {lab=VSS}
N 7600 -3100 7600 -3090 {lab=VSS}
N 7780 -3020 7850 -3020 {lab=lv_pfet_W075L070_source_PAD}
N 7640 -3170 7640 -3140 {lab=VDD}
N 7420 -3140 7640 -3140 {lab=VDD}
N 7600 -3170 7600 -3160 {lab=VDD}
N 7370 -3160 7600 -3160 {lab=VDD}
N 7640 -3340 7640 -3310 {lab=VSS}
N 7400 -3340 7640 -3340 {lab=VSS}
N 7350 -3320 7600 -3320 {lab=VSS}
N 7600 -3320 7600 -3310 {lab=VSS}
N 7300 -3000 7480 -3000 {lab=guard_transistors_PAD}
N 7640 -3390 7640 -3360 {lab=VDD}
N 7420 -3360 7640 -3360 {lab=VDD}
N 7600 -3390 7600 -3380 {lab=VDD}
N 7370 -3380 7600 -3380 {lab=VDD}
N 7640 -3560 7640 -3530 {lab=VSS}
N 7400 -3560 7640 -3560 {lab=VSS}
N 7350 -3540 7600 -3540 {lab=VSS}
N 7600 -3540 7600 -3530 {lab=VSS}
N 7780 -3460 7850 -3460 {lab=lv_pfet_W075L070_gate_PAD}
N 7640 -3610 7640 -3580 {lab=VDD}
N 7420 -3580 7640 -3580 {lab=VDD}
N 7600 -3610 7600 -3600 {lab=VDD}
N 7370 -3600 7600 -3600 {lab=VDD}
N 7640 -3780 7640 -3750 {lab=VSS}
N 7400 -3780 7640 -3780 {lab=VSS}
N 7350 -3760 7600 -3760 {lab=VSS}
N 7600 -3760 7600 -3750 {lab=VSS}
N 7640 -3830 7640 -3800 {lab=VDD}
N 7420 -3800 7640 -3800 {lab=VDD}
N 7600 -3830 7600 -3820 {lab=VDD}
N 7370 -3820 7600 -3820 {lab=VDD}
N 7640 -4000 7640 -3970 {lab=VSS}
N 7400 -4000 7640 -4000 {lab=VSS}
N 7350 -3980 7600 -3980 {lab=VSS}
N 7600 -3980 7600 -3970 {lab=VSS}
N 7780 -3900 7850 -3900 {lab=lv_pfet_W075L070_drain_PAD}
N 7640 -4050 7640 -4020 {lab=VDD}
N 7420 -4020 7640 -4020 {lab=VDD}
N 7600 -4050 7600 -4040 {lab=VDD}
N 7370 -4040 7600 -4040 {lab=VDD}
N 7640 -4220 7640 -4190 {lab=VSS}
N 7400 -4220 7640 -4220 {lab=VSS}
N 7350 -4200 7600 -4200 {lab=VSS}
N 7600 -4200 7600 -4190 {lab=VSS}
N 7300 -3440 7480 -3440 {lab=guard_transistors_PAD}
N 7300 -3440 7300 -3000 {lab=guard_transistors_PAD}
N 7260 -3900 7480 -3900 {lab=lv_pfet_W075L070_drain_PAD}
N 7100 -3780 7100 -3720 {lab=guard_transistors_PAD}
N 7100 -3780 7300 -3780 {lab=guard_transistors_PAD}
N 7060 -3460 7480 -3460 {lab=lv_pfet_W075L070_gate_PAD}
N 7060 -3500 7060 -3460 {lab=lv_pfet_W075L070_gate_PAD}
N 7180 -3020 7480 -3020 {lab=lv_pfet_W075L070_source_PAD}
N 7180 -3500 7180 -3020 {lab=lv_pfet_W075L070_source_PAD}
N 7260 -3900 7260 -3480 {lab=lv_pfet_W075L070_drain_PAD}
N 7100 -3480 7260 -3480 {lab=lv_pfet_W075L070_drain_PAD}
N 7100 -3500 7100 -3480 {lab=lv_pfet_W075L070_drain_PAD}
N 7140 -3500 7140 -3260 {lab=VDD}
N 5020 -270 5240 -270 {lab=VSS}
N 4860 -250 5080 -250 {lab=VDD}
N 5040 -220 5260 -220 {lab=VSS}
N 4840 -200 5060 -200 {lab=VDD}
N 7640 -4270 7640 -4240 {lab=VDD}
N 7420 -4240 7640 -4240 {lab=VDD}
N 7600 -4270 7600 -4260 {lab=VDD}
N 7370 -4260 7600 -4260 {lab=VDD}
N 7640 -4440 7640 -4410 {lab=VSS}
N 7400 -4440 7640 -4440 {lab=VSS}
N 7350 -4420 7600 -4420 {lab=VSS}
N 7600 -4420 7600 -4410 {lab=VSS}
N 7780 -4340 7850 -4340 {lab=hv_nfet_W075L070_source_PAD}
N 7640 -4490 7640 -4460 {lab=VDD}
N 7420 -4460 7640 -4460 {lab=VDD}
N 7600 -4490 7600 -4480 {lab=VDD}
N 7370 -4480 7600 -4480 {lab=VDD}
N 7640 -4660 7640 -4630 {lab=VSS}
N 7400 -4660 7640 -4660 {lab=VSS}
N 7350 -4640 7600 -4640 {lab=VSS}
N 7600 -4640 7600 -4630 {lab=VSS}
N 7300 -4320 7480 -4320 {lab=guard_transistors_PAD}
N 7640 -4710 7640 -4680 {lab=VDD}
N 7420 -4680 7640 -4680 {lab=VDD}
N 7600 -4710 7600 -4700 {lab=VDD}
N 7370 -4700 7600 -4700 {lab=VDD}
N 7640 -4880 7640 -4850 {lab=VSS}
N 7400 -4880 7640 -4880 {lab=VSS}
N 7350 -4860 7600 -4860 {lab=VSS}
N 7600 -4860 7600 -4850 {lab=VSS}
N 7780 -4780 7850 -4780 {lab=hv_nfet_W075L070_gate_PAD}
N 7640 -4930 7640 -4900 {lab=VDD}
N 7420 -4900 7640 -4900 {lab=VDD}
N 7600 -4930 7600 -4920 {lab=VDD}
N 7370 -4920 7600 -4920 {lab=VDD}
N 7640 -5100 7640 -5070 {lab=VSS}
N 7400 -5100 7640 -5100 {lab=VSS}
N 7350 -5080 7600 -5080 {lab=VSS}
N 7600 -5080 7600 -5070 {lab=VSS}
N 7640 -5150 7640 -5120 {lab=VDD}
N 7420 -5120 7640 -5120 {lab=VDD}
N 7600 -5150 7600 -5140 {lab=VDD}
N 7370 -5140 7600 -5140 {lab=VDD}
N 7640 -5320 7640 -5290 {lab=VSS}
N 7400 -5320 7640 -5320 {lab=VSS}
N 7350 -5300 7600 -5300 {lab=VSS}
N 7600 -5300 7600 -5290 {lab=VSS}
N 7780 -5220 7850 -5220 {lab=hv_nfet_W075L070_drain_PAD}
N 7640 -5370 7640 -5340 {lab=VDD}
N 7420 -5340 7640 -5340 {lab=VDD}
N 7600 -5370 7600 -5360 {lab=VDD}
N 7370 -5360 7600 -5360 {lab=VDD}
N 7640 -5540 7640 -5510 {lab=VSS}
N 7400 -5540 7640 -5540 {lab=VSS}
N 7350 -5520 7600 -5520 {lab=VSS}
N 7600 -5520 7600 -5510 {lab=VSS}
N 7300 -4760 7480 -4760 {lab=guard_transistors_PAD}
N 7300 -4760 7300 -4320 {lab=guard_transistors_PAD}
N 7100 -5100 7100 -5040 {lab=guard_transistors_PAD}
N 7100 -5100 7300 -5100 {lab=guard_transistors_PAD}
N 7180 -4340 7480 -4340 {lab=hv_nfet_W075L070_source_PAD}
N 7180 -4820 7180 -4340 {lab=hv_nfet_W075L070_source_PAD}
N 7260 -5220 7260 -4800 {lab=hv_nfet_W075L070_drain_PAD}
N 7100 -4800 7260 -4800 {lab=hv_nfet_W075L070_drain_PAD}
N 7100 -4820 7100 -4800 {lab=hv_nfet_W075L070_drain_PAD}
N 7140 -4820 7140 -4580 {lab=VSS}
N 7140 -4580 7350 -4580 {lab=VSS}
N 7140 -3260 7370 -3260 {lab=VDD}
N 6920 -200 7140 -200 {lab=VDD}
N 6900 -220 7120 -220 {lab=VSS}
N 6940 -250 7160 -250 {lab=VDD}
N 6880 -270 7100 -270 {lab=VSS}
N 7300 -4320 7300 -3880 {lab=guard_transistors_PAD}
N 7300 -3000 7300 -2560 {lab=guard_transistors_PAD}
N 7640 -5590 7640 -5560 {lab=VDD}
N 7420 -5560 7640 -5560 {lab=VDD}
N 7600 -5590 7600 -5580 {lab=VDD}
N 7370 -5580 7600 -5580 {lab=VDD}
N 7640 -5760 7640 -5730 {lab=VSS}
N 7400 -5760 7640 -5760 {lab=VSS}
N 7350 -5740 7600 -5740 {lab=VSS}
N 7600 -5740 7600 -5730 {lab=VSS}
N 7780 -5660 7850 -5660 {lab=hv_pfet_W075L070_source_PAD}
N 7640 -5810 7640 -5780 {lab=VDD}
N 7420 -5780 7640 -5780 {lab=VDD}
N 7600 -5810 7600 -5800 {lab=VDD}
N 7370 -5800 7600 -5800 {lab=VDD}
N 7640 -5980 7640 -5950 {lab=VSS}
N 7400 -5980 7640 -5980 {lab=VSS}
N 7350 -5960 7600 -5960 {lab=VSS}
N 7600 -5960 7600 -5950 {lab=VSS}
N 7300 -5640 7480 -5640 {lab=guard_transistors_PAD}
N 7640 -6030 7640 -6000 {lab=VDD}
N 7420 -6000 7640 -6000 {lab=VDD}
N 7600 -6030 7600 -6020 {lab=VDD}
N 7370 -6020 7600 -6020 {lab=VDD}
N 7640 -6200 7640 -6170 {lab=VSS}
N 7400 -6200 7640 -6200 {lab=VSS}
N 7350 -6180 7600 -6180 {lab=VSS}
N 7600 -6180 7600 -6170 {lab=VSS}
N 7780 -6100 7850 -6100 {lab=hv_pfet_W075L070_gate_PAD}
N 7640 -6250 7640 -6220 {lab=VDD}
N 7420 -6220 7640 -6220 {lab=VDD}
N 7600 -6250 7600 -6240 {lab=VDD}
N 7370 -6240 7600 -6240 {lab=VDD}
N 7640 -6420 7640 -6390 {lab=VSS}
N 7400 -6420 7640 -6420 {lab=VSS}
N 7350 -6400 7600 -6400 {lab=VSS}
N 7600 -6400 7600 -6390 {lab=VSS}
N 7640 -6470 7640 -6440 {lab=VDD}
N 7420 -6440 7640 -6440 {lab=VDD}
N 7600 -6470 7600 -6460 {lab=VDD}
N 7370 -6460 7600 -6460 {lab=VDD}
N 7640 -6640 7640 -6610 {lab=VSS}
N 7400 -6640 7640 -6640 {lab=VSS}
N 7350 -6620 7600 -6620 {lab=VSS}
N 7600 -6620 7600 -6610 {lab=VSS}
N 7780 -6540 7850 -6540 {lab=hv_pfet_W075L070_drain_PAD}
N 7640 -6690 7640 -6660 {lab=VDD}
N 7420 -6660 7640 -6660 {lab=VDD}
N 7600 -6690 7600 -6680 {lab=VDD}
N 7370 -6680 7600 -6680 {lab=VDD}
N 7640 -6860 7640 -6830 {lab=VSS}
N 7400 -6860 7640 -6860 {lab=VSS}
N 7350 -6840 7600 -6840 {lab=VSS}
N 7600 -6840 7600 -6830 {lab=VSS}
N 7300 -6080 7480 -6080 {lab=guard_transistors_PAD}
N 7300 -6080 7300 -5640 {lab=guard_transistors_PAD}
N 7260 -6540 7480 -6540 {lab=hv_pfet_W075L070_drain_PAD}
N 7100 -6420 7100 -6360 {lab=guard_transistors_PAD}
N 7100 -6420 7300 -6420 {lab=guard_transistors_PAD}
N 7060 -6100 7480 -6100 {lab=hv_pfet_W075L070_gate_PAD}
N 7060 -6140 7060 -6100 {lab=hv_pfet_W075L070_gate_PAD}
N 7180 -5660 7480 -5660 {lab=hv_pfet_W075L070_source_PAD}
N 7180 -6140 7180 -5660 {lab=hv_pfet_W075L070_source_PAD}
N 7260 -6540 7260 -6120 {lab=hv_pfet_W075L070_drain_PAD}
N 7100 -6120 7260 -6120 {lab=hv_pfet_W075L070_drain_PAD}
N 7100 -6140 7100 -6120 {lab=hv_pfet_W075L070_drain_PAD}
N 7140 -6140 7140 -5900 {lab=VDD}
N 7300 -5640 7300 -5200 {lab=guard_transistors_PAD}
N 7640 -6910 7640 -6880 {lab=VDD}
N 7420 -6880 7640 -6880 {lab=VDD}
N 7600 -6910 7600 -6900 {lab=VDD}
N 7370 -6900 7600 -6900 {lab=VDD}
N 7350 -7060 7600 -7060 {lab=VSS}
N 7600 -7060 7600 -7050 {lab=VSS}
N 7300 -6980 7850 -6980 {lab=guard_transistors_PAD}
N 7320 -270 7350 -270 {lab=VSS}
N 7160 -250 7370 -250 {lab=VDD}
N 7340 -220 7400 -220 {lab=VSS}
N 7140 -200 7420 -200 {lab=VDD}
N 7140 -200 7140 20 {lab=VDD}
N 7160 -20 7170 -20 {lab=VDD}
N 7140 20 7170 20 {lab=VDD}
N 7160 -250 7160 -20 {lab=VDD}
N 7310 20 7340 20 {lab=VSS}
N 7340 -220 7340 20 {lab=VSS}
N 7320 -270 7320 -20 {lab=VSS}
N 7310 -20 7320 -20 {lab=VSS}
N 3300 -200 3300 20 {lab=VDD}
N 3320 -20 3330 -20 {lab=VDD}
N 3300 20 3330 20 {lab=VDD}
N 3320 -250 3320 -20 {lab=VDD}
N 3470 20 3500 20 {lab=VSS}
N 3500 -220 3500 20 {lab=VSS}
N 3480 -270 3480 -20 {lab=VSS}
N 3470 -20 3480 -20 {lab=VSS}
N 7640 -300 7640 -280 {lab=VDD}
N 7420 -280 7640 -280 {lab=VDD}
N 7370 -300 7640 -300 {lab=VDD}
N 7640 -480 7640 -450 {lab=VSS}
N 7400 -480 7640 -480 {lab=VSS}
N 7350 -460 7600 -460 {lab=VSS}
N 7640 -310 7840 -310 {lab=VDD}
N 7840 -380 7850 -380 {lab=VDD}
N 7840 -380 7840 -310 {lab=VDD}
N 7600 -460 7600 -450 {lab=VSS}
N 7640 -750 7640 -720 {lab=VDD}
N 7420 -720 7640 -720 {lab=VDD}
N 7600 -750 7600 -740 {lab=VDD}
N 7370 -740 7600 -740 {lab=VDD}
N 7640 -900 7640 -890 {lab=VSS}
N 7400 -920 7640 -920 {lab=VSS}
N 7350 -900 7640 -900 {lab=VSS}
N 7640 -900 7840 -900 {lab=VSS}
N 7840 -900 7840 -820 {lab=VSS}
N 7840 -820 7850 -820 {lab=VSS}
N 5280 -200 5280 20 {lab=VDD}
N 5300 -20 5310 -20 {lab=VDD}
N 5280 20 5310 20 {lab=VDD}
N 5300 -250 5300 -20 {lab=VDD}
N 5550 20 5580 20 {lab=VSS}
N 5580 -220 5580 20 {lab=VSS}
N 5560 -270 5560 -20 {lab=VSS}
N 5550 -20 5560 -20 {lab=VSS}
N 5380 160 5380 220 {lab=GUARDSENSE_ASIG_PAD}
N 5480 160 5480 220 {lab=GUARDSENSE_SENSE_PAD}
N 3520 -200 3520 20 {lab=VDD}
N 3540 -20 3550 -20 {lab=VDD}
N 3520 20 3550 20 {lab=VDD}
N 3540 -250 3540 -20 {lab=VDD}
N 3690 20 3720 20 {lab=VSS}
N 3720 -220 3720 20 {lab=VSS}
N 3700 -270 3700 -20 {lab=VSS}
N 3690 -20 3700 -20 {lab=VSS}
N 3740 -200 3740 20 {lab=VDD}
N 3760 -20 3770 -20 {lab=VDD}
N 3740 20 3770 20 {lab=VDD}
N 3760 -250 3760 -20 {lab=VDD}
N 3910 -20 3920 -20 {lab=VSS}
N 3920 -270 3920 -20 {lab=VSS}
N 3910 20 3940 20 {lab=VSS}
N 3940 -220 3940 20 {lab=VSS}
N 3960 -200 3960 20 {lab=VDD}
N 3980 -20 3990 -20 {lab=VDD}
N 3960 20 3990 20 {lab=VDD}
N 3980 -250 3980 -20 {lab=VDD}
N 4130 20 4160 20 {lab=VSS}
N 4160 -220 4160 20 {lab=VSS}
N 4140 -270 4140 -20 {lab=VSS}
N 4130 -20 4140 -20 {lab=VSS}
N 4060 -140 4060 220 {lab=ASIG_FOUNDRY_PAD}
N 4840 -200 4840 20 {lab=VDD}
N 4860 -20 4870 -20 {lab=VDD}
N 4840 20 4870 20 {lab=VDD}
N 4860 -250 4860 -20 {lab=VDD}
N 5010 -20 5020 -20 {lab=VSS}
N 5020 -270 5020 -20 {lab=VSS}
N 5010 20 5040 20 {lab=VSS}
N 5040 -220 5040 20 {lab=VSS}
N 5060 -200 5060 20 {lab=VDD}
N 5080 -20 5090 -20 {lab=VDD}
N 5060 20 5090 20 {lab=VDD}
N 5080 -250 5080 -20 {lab=VDD}
N 5230 20 5260 20 {lab=VSS}
N 5260 -220 5260 20 {lab=VSS}
N 5230 -20 5240 -20 {lab=VSS}
N 5240 -270 5240 -20 {lab=VSS}
N 6260 -200 6260 20 {lab=VDD}
N 6280 -20 6290 -20 {lab=VDD}
N 6260 20 6290 20 {lab=VDD}
N 6280 -250 6280 -20 {lab=VDD}
N 6430 20 6460 20 {lab=VSS}
N 6460 -220 6460 20 {lab=VSS}
N 6440 -270 6440 -20 {lab=VSS}
N 6430 -20 6440 -20 {lab=VSS}
N 6920 -200 6920 20 {lab=VDD}
N 6940 -20 6950 -20 {lab=VDD}
N 6920 20 6950 20 {lab=VDD}
N 6940 -250 6940 -20 {lab=VDD}
N 7090 20 7120 20 {lab=VSS}
N 7120 -220 7120 20 {lab=VSS}
N 7100 -270 7100 -20 {lab=VSS}
N 7090 -20 7100 -20 {lab=VSS}
N 6360 160 6360 220 {lab=EMPTY_PAD}
N 6700 -200 6700 20 {lab=VDD}
N 6720 -20 6730 -20 {lab=VDD}
N 6700 20 6730 20 {lab=VDD}
N 6720 -250 6720 -20 {lab=VDD}
N 6870 -20 6880 -20 {lab=VSS}
N 6880 -270 6880 -20 {lab=VSS}
N 6870 20 6900 20 {lab=VSS}
N 6900 -220 6900 20 {lab=VSS}
N 2640 -270 3480 -270 {lab=VSS}
N 2620 -250 3320 -250 {lab=VDD}
N 2590 -220 3500 -220 {lab=VSS}
N 2570 -200 3300 -200 {lab=VDD}
N 2350 -480 2570 -480 {lab=VDD}
N 2390 -460 2390 -450 {lab=VDD}
N 2350 -480 2350 -450 {lab=VDD}
N 2390 -460 2620 -460 {lab=VDD}
N 2350 -300 2350 -280 {lab=VSS}
N 2350 -280 2590 -280 {lab=VSS}
N 2350 -300 2640 -300 {lab=VSS}
N 2150 -300 2350 -300 {lab=VSS}
N 2150 -380 2150 -300 {lab=VSS}
N 2140 -380 2150 -380 {lab=VSS}
N 6340 -320 6340 -140 {lab=PAD_GUARD_PAD}
N 7020 -320 7020 220 {lab=PAD_GUARD_PAD}
N 6340 -320 7020 -320 {lab=PAD_GUARD_PAD}
N 5430 -320 5430 -140 {lab=PAD_GUARD_PAD}
N 5370 -400 5370 -140 {lab=#net1}
N 5480 -400 5480 -140 {lab=#net2}
N 6360 -400 6360 -140 {lab=EMPTY_PAD}
N 7640 -530 7640 -500 {lab=VDD}
N 7420 -500 7640 -500 {lab=VDD}
N 7600 -530 7600 -520 {lab=VDD}
N 7370 -520 7600 -520 {lab=VDD}
N 7600 -680 7600 -670 {lab=VSS}
N 7350 -680 7600 -680 {lab=VSS}
N 7640 -700 7640 -670 {lab=VSS}
N 7400 -700 7640 -700 {lab=VSS}
N 2350 -700 2570 -700 {lab=VDD}
N 2390 -680 2390 -670 {lab=VDD}
N 2350 -700 2350 -670 {lab=VDD}
N 2390 -680 2620 -680 {lab=VDD}
N 2390 -530 2390 -520 {lab=VSS}
N 2390 -520 2640 -520 {lab=VSS}
N 2350 -530 2350 -500 {lab=VSS}
N 2350 -500 2590 -500 {lab=VSS}
N 2350 -900 2350 -890 {lab=VDD}
N 2350 -920 2570 -920 {lab=VDD}
N 2350 -920 2350 -900 {lab=VDD}
N 2350 -750 2350 -720 {lab=VSS}
N 2350 -720 2590 -720 {lab=VSS}
N 2390 -740 2640 -740 {lab=VSS}
N 2150 -890 2350 -890 {lab=VDD}
N 2140 -820 2150 -820 {lab=VDD}
N 2150 -890 2150 -820 {lab=VDD}
N 2350 -900 2620 -900 {lab=VDD}
N 2390 -750 2390 -740 {lab=VSS}
N 7300 -2560 7480 -2560 {lab=guard_transistors_PAD}
N 7300 -3880 7480 -3880 {lab=guard_transistors_PAD}
N 7300 -5200 7480 -5200 {lab=guard_transistors_PAD}
N 7300 -6520 7480 -6520 {lab=guard_transistors_PAD}
N 7640 -970 7640 -940 {lab=VDD}
N 7420 -940 7640 -940 {lab=VDD}
N 7600 -970 7600 -960 {lab=VDD}
N 7370 -960 7600 -960 {lab=VDD}
N 7600 -1120 7600 -1110 {lab=VSS}
N 7350 -1120 7600 -1120 {lab=VSS}
N 7640 -1140 7640 -1110 {lab=VSS}
N 7400 -1140 7640 -1140 {lab=VSS}
N 7640 -1190 7640 -1160 {lab=VDD}
N 7420 -1160 7640 -1160 {lab=VDD}
N 7600 -1190 7600 -1180 {lab=VDD}
N 7370 -1180 7600 -1180 {lab=VDD}
N 7640 -1360 7640 -1330 {lab=VSS}
N 7400 -1360 7640 -1360 {lab=VSS}
N 7350 -1340 7600 -1340 {lab=VSS}
N 7600 -1340 7600 -1330 {lab=VSS}
N 7300 -1260 7850 -1260 {lab=guard_transistors_PAD}
N 7060 -4780 7480 -4780 {lab=hv_nfet_W075L070_gate_PAD}
N 7060 -4820 7060 -4780 {lab=hv_nfet_W075L070_gate_PAD}
N 7260 -5220 7480 -5220 {lab=hv_nfet_W075L070_drain_PAD}
N 7300 -6980 7300 -6520 {lab=guard_transistors_PAD}
N 7640 -1410 7640 -1380 {lab=VDD}
N 7420 -1380 7640 -1380 {lab=VDD}
N 7600 -1410 7600 -1400 {lab=VDD}
N 7370 -1400 7600 -1400 {lab=VDD}
N 7600 -1560 7600 -1550 {lab=VSS}
N 7350 -1560 7600 -1560 {lab=VSS}
N 7640 -1580 7640 -1550 {lab=VSS}
N 7400 -1580 7640 -1580 {lab=VSS}
N 7300 -1680 7300 -1260 {lab=guard_transistors_PAD}
N 7370 -300 7370 -250 {lab=VDD}
N 7420 -280 7420 -200 {lab=VDD}
N 7400 -480 7400 -220 {lab=VSS}
N 7420 -500 7420 -280 {lab=VDD}
N 7370 -520 7370 -300 {lab=VDD}
N 7350 -460 7350 -270 {lab=VSS}
N 7280 -17770 7420 -17770 {lab=VDD}
N 7080 -17750 7400 -17750 {lab=VSS}
N 7260 -17720 7370 -17720 {lab=VDD}
N 7100 -17700 7350 -17700 {lab=VSS}
N 3540 -17770 3760 -17770 {lab=VDD}
N 3560 -17750 3780 -17750 {lab=VSS}
N 3520 -17720 3740 -17720 {lab=VDD}
N 3580 -17700 3800 -17700 {lab=VSS}
N 2640 -300 2640 -270 {lab=VSS}
N 2620 -17720 2860 -17720 {lab=VDD}
N 2620 -460 2620 -250 {lab=VDD}
N 2590 -280 2590 -220 {lab=VSS}
N 2590 -17750 2590 -17460 {lab=VSS}
N 2590 -17750 2680 -17750 {lab=VSS}
N 2570 -17770 2880 -17770 {lab=VDD}
N 2570 -480 2570 -200 {lab=VDD}
N 3520 -200 3740 -200 {lab=VDD}
N 3500 -220 3720 -220 {lab=VSS}
N 3540 -250 3760 -250 {lab=VDD}
N 3480 -270 3700 -270 {lab=VSS}
N 2350 -7100 2570 -7100 {lab=VDD}
N 2390 -7080 2390 -7070 {lab=VDD}
N 2350 -7100 2350 -7070 {lab=VDD}
N 2390 -7080 2620 -7080 {lab=VDD}
N 2350 -6930 2350 -6900 {lab=VSS}
N 2350 -6900 2590 -6900 {lab=VSS}
N 2390 -6920 2640 -6920 {lab=VSS}
N 2390 -6930 2390 -6920 {lab=VSS}
N 2350 -6880 2570 -6880 {lab=VDD}
N 2390 -6860 2390 -6850 {lab=VDD}
N 2350 -6880 2350 -6850 {lab=VDD}
N 2390 -6860 2620 -6860 {lab=VDD}
N 2390 -6710 2390 -6700 {lab=VSS}
N 2390 -6700 2640 -6700 {lab=VSS}
N 2350 -6710 2350 -6680 {lab=VSS}
N 2350 -6680 2590 -6680 {lab=VSS}
N 2150 -7000 2510 -7000 {lab=TOFILL23_PAD}
N 2350 -6660 2570 -6660 {lab=VDD}
N 2390 -6640 2390 -6630 {lab=VDD}
N 2350 -6660 2350 -6630 {lab=VDD}
N 2390 -6640 2620 -6640 {lab=VDD}
N 2350 -6490 2350 -6460 {lab=VSS}
N 2350 -6460 2590 -6460 {lab=VSS}
N 2390 -6480 2640 -6480 {lab=VSS}
N 2390 -6490 2390 -6480 {lab=VSS}
N 2350 -6440 2570 -6440 {lab=VDD}
N 2390 -6420 2390 -6410 {lab=VDD}
N 2350 -6440 2350 -6410 {lab=VDD}
N 2390 -6420 2620 -6420 {lab=VDD}
N 2390 -6270 2390 -6260 {lab=VSS}
N 2390 -6260 2640 -6260 {lab=VSS}
N 2350 -6270 2350 -6240 {lab=VSS}
N 2350 -6240 2590 -6240 {lab=VSS}
N 2150 -6560 2510 -6560 {lab=TOFILL24_PAD}
N 2350 -6220 2570 -6220 {lab=VDD}
N 2390 -6200 2390 -6190 {lab=VDD}
N 2350 -6220 2350 -6190 {lab=VDD}
N 2390 -6200 2620 -6200 {lab=VDD}
N 2350 -6050 2350 -6020 {lab=VSS}
N 2350 -6020 2590 -6020 {lab=VSS}
N 2390 -6040 2640 -6040 {lab=VSS}
N 2390 -6050 2390 -6040 {lab=VSS}
N 2350 -6000 2570 -6000 {lab=VDD}
N 2390 -5980 2390 -5970 {lab=VDD}
N 2350 -6000 2350 -5970 {lab=VDD}
N 2390 -5980 2620 -5980 {lab=VDD}
N 2390 -5830 2390 -5820 {lab=VSS}
N 2390 -5820 2640 -5820 {lab=VSS}
N 2350 -5830 2350 -5800 {lab=VSS}
N 2350 -5800 2590 -5800 {lab=VSS}
N 2150 -6120 2510 -6120 {lab=TOFILL25_PAD}
N 2350 -5780 2570 -5780 {lab=VDD}
N 2390 -5760 2390 -5750 {lab=VDD}
N 2350 -5780 2350 -5750 {lab=VDD}
N 2390 -5760 2620 -5760 {lab=VDD}
N 2350 -5610 2350 -5580 {lab=VSS}
N 2350 -5580 2590 -5580 {lab=VSS}
N 2390 -5600 2640 -5600 {lab=VSS}
N 2390 -5610 2390 -5600 {lab=VSS}
N 2350 -5560 2570 -5560 {lab=VDD}
N 2390 -5540 2390 -5530 {lab=VDD}
N 2350 -5560 2350 -5530 {lab=VDD}
N 2390 -5540 2620 -5540 {lab=VDD}
N 2390 -5390 2390 -5380 {lab=VSS}
N 2390 -5380 2640 -5380 {lab=VSS}
N 2350 -5390 2350 -5360 {lab=VSS}
N 2350 -5360 2590 -5360 {lab=VSS}
N 2150 -5680 2510 -5680 {lab=TOFILL26_PAD}
N 2350 -5340 2570 -5340 {lab=VDD}
N 2390 -5320 2390 -5310 {lab=VDD}
N 2350 -5340 2350 -5310 {lab=VDD}
N 2390 -5320 2620 -5320 {lab=VDD}
N 2350 -5170 2350 -5140 {lab=VSS}
N 2350 -5140 2590 -5140 {lab=VSS}
N 2390 -5160 2640 -5160 {lab=VSS}
N 2390 -5170 2390 -5160 {lab=VSS}
N 2350 -5120 2570 -5120 {lab=VDD}
N 2390 -5100 2390 -5090 {lab=VDD}
N 2350 -5120 2350 -5090 {lab=VDD}
N 2390 -5100 2620 -5100 {lab=VDD}
N 2390 -4950 2390 -4940 {lab=VSS}
N 2390 -4940 2640 -4940 {lab=VSS}
N 2350 -4950 2350 -4920 {lab=VSS}
N 2350 -4920 2590 -4920 {lab=VSS}
N 2150 -5240 2510 -5240 {lab=TOFILL27_PAD}
N 2350 -4900 2570 -4900 {lab=VDD}
N 2390 -4880 2390 -4870 {lab=VDD}
N 2350 -4900 2350 -4870 {lab=VDD}
N 2390 -4880 2620 -4880 {lab=VDD}
N 2350 -4730 2350 -4700 {lab=VSS}
N 2350 -4700 2590 -4700 {lab=VSS}
N 2390 -4720 2640 -4720 {lab=VSS}
N 2390 -4730 2390 -4720 {lab=VSS}
N 2350 -4680 2570 -4680 {lab=VDD}
N 2390 -4660 2390 -4650 {lab=VDD}
N 2350 -4680 2350 -4650 {lab=VDD}
N 2390 -4660 2620 -4660 {lab=VDD}
N 2390 -4510 2390 -4500 {lab=VSS}
N 2390 -4500 2640 -4500 {lab=VSS}
N 2350 -4510 2350 -4480 {lab=VSS}
N 2350 -4480 2590 -4480 {lab=VSS}
N 2150 -4800 2510 -4800 {lab=TOFILL28_PAD}
N 2350 -4460 2570 -4460 {lab=VDD}
N 2390 -4440 2390 -4430 {lab=VDD}
N 2350 -4460 2350 -4430 {lab=VDD}
N 2390 -4440 2620 -4440 {lab=VDD}
N 2350 -4290 2350 -4260 {lab=VSS}
N 2350 -4260 2590 -4260 {lab=VSS}
N 2390 -4280 2640 -4280 {lab=VSS}
N 2390 -4290 2390 -4280 {lab=VSS}
N 2350 -4240 2570 -4240 {lab=VDD}
N 2390 -4220 2390 -4210 {lab=VDD}
N 2350 -4240 2350 -4210 {lab=VDD}
N 2390 -4220 2620 -4220 {lab=VDD}
N 2390 -4070 2390 -4060 {lab=VSS}
N 2390 -4060 2640 -4060 {lab=VSS}
N 2350 -4070 2350 -4040 {lab=VSS}
N 2350 -4040 2590 -4040 {lab=VSS}
N 2150 -4360 2510 -4360 {lab=TOFILL29_PAD}
N 2350 -4020 2570 -4020 {lab=VDD}
N 2390 -4000 2390 -3990 {lab=VDD}
N 2350 -4020 2350 -3990 {lab=VDD}
N 2390 -4000 2620 -4000 {lab=VDD}
N 2350 -3850 2350 -3820 {lab=VSS}
N 2350 -3820 2590 -3820 {lab=VSS}
N 2390 -3840 2640 -3840 {lab=VSS}
N 2390 -3850 2390 -3840 {lab=VSS}
N 2350 -3800 2570 -3800 {lab=VDD}
N 2390 -3780 2390 -3770 {lab=VDD}
N 2350 -3800 2350 -3770 {lab=VDD}
N 2390 -3780 2620 -3780 {lab=VDD}
N 2390 -3630 2390 -3620 {lab=VSS}
N 2390 -3620 2640 -3620 {lab=VSS}
N 2350 -3630 2350 -3600 {lab=VSS}
N 2350 -3600 2590 -3600 {lab=VSS}
N 2150 -3920 2510 -3920 {lab=TOFILL30_PAD}
N 2350 -3580 2570 -3580 {lab=VDD}
N 2390 -3560 2390 -3550 {lab=VDD}
N 2350 -3580 2350 -3550 {lab=VDD}
N 2390 -3560 2620 -3560 {lab=VDD}
N 2350 -3410 2350 -3380 {lab=VSS}
N 2350 -3380 2590 -3380 {lab=VSS}
N 2390 -3400 2640 -3400 {lab=VSS}
N 2390 -3410 2390 -3400 {lab=VSS}
N 2350 -3360 2570 -3360 {lab=VDD}
N 2390 -3340 2390 -3330 {lab=VDD}
N 2350 -3360 2350 -3330 {lab=VDD}
N 2390 -3340 2620 -3340 {lab=VDD}
N 2390 -3190 2390 -3180 {lab=VSS}
N 2390 -3180 2640 -3180 {lab=VSS}
N 2350 -3190 2350 -3160 {lab=VSS}
N 2350 -3160 2590 -3160 {lab=VSS}
N 2150 -3480 2510 -3480 {lab=TOFILL31_PAD}
N 2350 -3140 2570 -3140 {lab=VDD}
N 2390 -3120 2390 -3110 {lab=VDD}
N 2350 -3140 2350 -3110 {lab=VDD}
N 2390 -3120 2620 -3120 {lab=VDD}
N 2350 -2970 2350 -2940 {lab=VSS}
N 2350 -2940 2590 -2940 {lab=VSS}
N 2390 -2960 2640 -2960 {lab=VSS}
N 2390 -2970 2390 -2960 {lab=VSS}
N 2350 -2920 2570 -2920 {lab=VDD}
N 2390 -2900 2390 -2890 {lab=VDD}
N 2350 -2920 2350 -2890 {lab=VDD}
N 2390 -2900 2620 -2900 {lab=VDD}
N 2390 -2750 2390 -2740 {lab=VSS}
N 2390 -2740 2640 -2740 {lab=VSS}
N 2350 -2750 2350 -2720 {lab=VSS}
N 2350 -2720 2590 -2720 {lab=VSS}
N 2350 -2700 2570 -2700 {lab=VDD}
N 2390 -2680 2390 -2670 {lab=VDD}
N 2350 -2700 2350 -2670 {lab=VDD}
N 2390 -2680 2620 -2680 {lab=VDD}
N 2350 -2530 2350 -2500 {lab=VSS}
N 2350 -2500 2590 -2500 {lab=VSS}
N 2390 -2520 2640 -2520 {lab=VSS}
N 2390 -2530 2390 -2520 {lab=VSS}
N 2350 -2480 2570 -2480 {lab=VDD}
N 2390 -2460 2390 -2450 {lab=VDD}
N 2350 -2480 2350 -2450 {lab=VDD}
N 2390 -2460 2620 -2460 {lab=VDD}
N 2390 -2310 2390 -2300 {lab=VSS}
N 2390 -2300 2640 -2300 {lab=VSS}
N 2350 -2310 2350 -2280 {lab=VSS}
N 2350 -2280 2590 -2280 {lab=VSS}
N 2150 -2600 2800 -2600 {lab=CHARGE_PUMP_G1_PAD}
N 2350 -2260 2570 -2260 {lab=VDD}
N 2390 -2240 2390 -2230 {lab=VDD}
N 2350 -2260 2350 -2230 {lab=VDD}
N 2390 -2240 2620 -2240 {lab=VDD}
N 2350 -2090 2350 -2060 {lab=VSS}
N 2350 -2060 2590 -2060 {lab=VSS}
N 2390 -2080 2640 -2080 {lab=VSS}
N 2390 -2090 2390 -2080 {lab=VSS}
N 2350 -2040 2570 -2040 {lab=VDD}
N 2390 -2020 2390 -2010 {lab=VDD}
N 2350 -2040 2350 -2010 {lab=VDD}
N 2390 -2020 2620 -2020 {lab=VDD}
N 2390 -1870 2390 -1860 {lab=VSS}
N 2390 -1860 2640 -1860 {lab=VSS}
N 2350 -1870 2350 -1840 {lab=VSS}
N 2350 -1840 2590 -1840 {lab=VSS}
N 2350 -1820 2570 -1820 {lab=VDD}
N 2390 -1800 2390 -1790 {lab=VDD}
N 2350 -1820 2350 -1790 {lab=VDD}
N 2390 -1800 2620 -1800 {lab=VDD}
N 2350 -1650 2350 -1620 {lab=VSS}
N 2350 -1620 2590 -1620 {lab=VSS}
N 2390 -1640 2640 -1640 {lab=VSS}
N 2390 -1650 2390 -1640 {lab=VSS}
N 2350 -1600 2570 -1600 {lab=VDD}
N 2390 -1580 2390 -1570 {lab=VDD}
N 2350 -1600 2350 -1570 {lab=VDD}
N 2390 -1580 2620 -1580 {lab=VDD}
N 2390 -1430 2390 -1420 {lab=VSS}
N 2390 -1420 2640 -1420 {lab=VSS}
N 2350 -1430 2350 -1400 {lab=VSS}
N 2350 -1400 2590 -1400 {lab=VSS}
N 2150 -1720 3160 -1720 {lab=CHARGE_PUMP_G2_PAD}
N 2350 -1380 2570 -1380 {lab=VDD}
N 2390 -1360 2390 -1350 {lab=VDD}
N 2350 -1380 2350 -1350 {lab=VDD}
N 2390 -1360 2620 -1360 {lab=VDD}
N 2350 -1210 2350 -1180 {lab=VSS}
N 2350 -1180 2590 -1180 {lab=VSS}
N 2390 -1200 2640 -1200 {lab=VSS}
N 2390 -1210 2390 -1200 {lab=VSS}
N 2350 -1160 2570 -1160 {lab=VDD}
N 2390 -1140 2390 -1130 {lab=VDD}
N 2350 -1160 2350 -1130 {lab=VDD}
N 2390 -1140 2620 -1140 {lab=VDD}
N 2390 -990 2390 -980 {lab=VSS}
N 2390 -980 2640 -980 {lab=VSS}
N 2350 -990 2350 -960 {lab=VSS}
N 2350 -960 2590 -960 {lab=VSS}
N 2150 -1280 2700 -1280 {lab=CHARGE_PUMP_GUARD_PAD}
N 2350 -7320 2570 -7320 {lab=VDD}
N 2390 -7300 2390 -7290 {lab=VDD}
N 2350 -7320 2350 -7290 {lab=VDD}
N 2390 -7300 2620 -7300 {lab=VDD}
N 2390 -7150 2390 -7140 {lab=VSS}
N 2390 -7140 2640 -7140 {lab=VSS}
N 2350 -7150 2350 -7120 {lab=VSS}
N 2350 -7120 2590 -7120 {lab=VSS}
N 2350 -7760 2570 -7760 {lab=VDD}
N 2390 -7740 2390 -7730 {lab=VDD}
N 2350 -7760 2350 -7730 {lab=VDD}
N 2390 -7740 2620 -7740 {lab=VDD}
N 2390 -7590 2390 -7580 {lab=VSS}
N 2390 -7580 2640 -7580 {lab=VSS}
N 2350 -7590 2350 -7560 {lab=VSS}
N 2350 -7560 2590 -7560 {lab=VSS}
N 2350 -8200 2570 -8200 {lab=VDD}
N 2390 -8180 2390 -8170 {lab=VDD}
N 2350 -8200 2350 -8170 {lab=VDD}
N 2390 -8180 2620 -8180 {lab=VDD}
N 2390 -8030 2390 -8020 {lab=VSS}
N 2390 -8020 2640 -8020 {lab=VSS}
N 2350 -8030 2350 -8000 {lab=VSS}
N 2350 -8000 2590 -8000 {lab=VSS}
N 2350 -11060 2570 -11060 {lab=VDD}
N 2390 -11040 2390 -11030 {lab=VDD}
N 2350 -11060 2350 -11030 {lab=VDD}
N 2390 -11040 2620 -11040 {lab=VDD}
N 2350 -10890 2350 -10860 {lab=VSS}
N 2350 -10860 2590 -10860 {lab=VSS}
N 2390 -10880 2640 -10880 {lab=VSS}
N 2390 -10890 2390 -10880 {lab=VSS}
N 2350 -10840 2570 -10840 {lab=VDD}
N 2390 -10820 2390 -10810 {lab=VDD}
N 2350 -10840 2350 -10810 {lab=VDD}
N 2390 -10820 2620 -10820 {lab=VDD}
N 2390 -10670 2390 -10660 {lab=VSS}
N 2390 -10660 2640 -10660 {lab=VSS}
N 2350 -10670 2350 -10640 {lab=VSS}
N 2350 -10640 2590 -10640 {lab=VSS}
N 2150 -10960 2510 -10960 {lab=TOFILL16_PAD}
N 2350 -11500 2570 -11500 {lab=VDD}
N 2390 -11480 2390 -11470 {lab=VDD}
N 2350 -11500 2350 -11470 {lab=VDD}
N 2390 -11480 2620 -11480 {lab=VDD}
N 2350 -11330 2350 -11300 {lab=VSS}
N 2350 -11300 2590 -11300 {lab=VSS}
N 2390 -11320 2640 -11320 {lab=VSS}
N 2390 -11330 2390 -11320 {lab=VSS}
N 2350 -11280 2570 -11280 {lab=VDD}
N 2390 -11260 2390 -11250 {lab=VDD}
N 2350 -11280 2350 -11250 {lab=VDD}
N 2390 -11260 2620 -11260 {lab=VDD}
N 2390 -11110 2390 -11100 {lab=VSS}
N 2390 -11100 2640 -11100 {lab=VSS}
N 2350 -11110 2350 -11080 {lab=VSS}
N 2350 -11080 2590 -11080 {lab=VSS}
N 2150 -11400 2510 -11400 {lab=TOFILL15_PAD}
N 2350 -11940 2570 -11940 {lab=VDD}
N 2390 -11920 2390 -11910 {lab=VDD}
N 2350 -11940 2350 -11910 {lab=VDD}
N 2390 -11920 2620 -11920 {lab=VDD}
N 2350 -11770 2350 -11740 {lab=VSS}
N 2350 -11740 2590 -11740 {lab=VSS}
N 2390 -11760 2640 -11760 {lab=VSS}
N 2390 -11770 2390 -11760 {lab=VSS}
N 2350 -11720 2570 -11720 {lab=VDD}
N 2390 -11700 2390 -11690 {lab=VDD}
N 2350 -11720 2350 -11690 {lab=VDD}
N 2390 -11700 2620 -11700 {lab=VDD}
N 2390 -11550 2390 -11540 {lab=VSS}
N 2390 -11540 2640 -11540 {lab=VSS}
N 2350 -11550 2350 -11520 {lab=VSS}
N 2350 -11520 2590 -11520 {lab=VSS}
N 2150 -11840 2510 -11840 {lab=TOFILL14_PAD}
N 2350 -12380 2570 -12380 {lab=VDD}
N 2390 -12360 2390 -12350 {lab=VDD}
N 2350 -12380 2350 -12350 {lab=VDD}
N 2390 -12360 2620 -12360 {lab=VDD}
N 2350 -12210 2350 -12180 {lab=VSS}
N 2350 -12180 2590 -12180 {lab=VSS}
N 2390 -12200 2640 -12200 {lab=VSS}
N 2390 -12210 2390 -12200 {lab=VSS}
N 2350 -12160 2570 -12160 {lab=VDD}
N 2390 -12140 2390 -12130 {lab=VDD}
N 2350 -12160 2350 -12130 {lab=VDD}
N 2390 -12140 2620 -12140 {lab=VDD}
N 2390 -11990 2390 -11980 {lab=VSS}
N 2390 -11980 2640 -11980 {lab=VSS}
N 2350 -11990 2350 -11960 {lab=VSS}
N 2350 -11960 2590 -11960 {lab=VSS}
N 2150 -12280 2510 -12280 {lab=TOFILL13_PAD}
N 2350 -12820 2570 -12820 {lab=VDD}
N 2390 -12800 2390 -12790 {lab=VDD}
N 2350 -12820 2350 -12790 {lab=VDD}
N 2390 -12800 2620 -12800 {lab=VDD}
N 2350 -12650 2350 -12620 {lab=VSS}
N 2350 -12620 2590 -12620 {lab=VSS}
N 2390 -12640 2640 -12640 {lab=VSS}
N 2390 -12650 2390 -12640 {lab=VSS}
N 2350 -12600 2570 -12600 {lab=VDD}
N 2390 -12580 2390 -12570 {lab=VDD}
N 2350 -12600 2350 -12570 {lab=VDD}
N 2390 -12580 2620 -12580 {lab=VDD}
N 2390 -12430 2390 -12420 {lab=VSS}
N 2390 -12420 2640 -12420 {lab=VSS}
N 2350 -12430 2350 -12400 {lab=VSS}
N 2350 -12400 2590 -12400 {lab=VSS}
N 2150 -12720 2510 -12720 {lab=TOFILL12_PAD}
N 2350 -13260 2570 -13260 {lab=VDD}
N 2390 -13240 2390 -13230 {lab=VDD}
N 2350 -13260 2350 -13230 {lab=VDD}
N 2390 -13240 2620 -13240 {lab=VDD}
N 2350 -13090 2350 -13060 {lab=VSS}
N 2350 -13060 2590 -13060 {lab=VSS}
N 2390 -13080 2640 -13080 {lab=VSS}
N 2390 -13090 2390 -13080 {lab=VSS}
N 2350 -13040 2570 -13040 {lab=VDD}
N 2390 -13020 2390 -13010 {lab=VDD}
N 2350 -13040 2350 -13010 {lab=VDD}
N 2390 -13020 2620 -13020 {lab=VDD}
N 2390 -12870 2390 -12860 {lab=VSS}
N 2390 -12860 2640 -12860 {lab=VSS}
N 2350 -12870 2350 -12840 {lab=VSS}
N 2350 -12840 2590 -12840 {lab=VSS}
N 2150 -13160 2510 -13160 {lab=TOFILL11_PAD}
N 2350 -13700 2570 -13700 {lab=VDD}
N 2390 -13680 2390 -13670 {lab=VDD}
N 2350 -13700 2350 -13670 {lab=VDD}
N 2390 -13680 2620 -13680 {lab=VDD}
N 2350 -13530 2350 -13500 {lab=VSS}
N 2350 -13500 2590 -13500 {lab=VSS}
N 2390 -13520 2640 -13520 {lab=VSS}
N 2390 -13530 2390 -13520 {lab=VSS}
N 2350 -13480 2570 -13480 {lab=VDD}
N 2390 -13460 2390 -13450 {lab=VDD}
N 2350 -13480 2350 -13450 {lab=VDD}
N 2390 -13460 2620 -13460 {lab=VDD}
N 2390 -13310 2390 -13300 {lab=VSS}
N 2390 -13300 2640 -13300 {lab=VSS}
N 2350 -13310 2350 -13280 {lab=VSS}
N 2350 -13280 2590 -13280 {lab=VSS}
N 2150 -13600 2510 -13600 {lab=TOFILL10_PAD}
N 2350 -14140 2570 -14140 {lab=VDD}
N 2390 -14120 2390 -14110 {lab=VDD}
N 2350 -14140 2350 -14110 {lab=VDD}
N 2390 -14120 2620 -14120 {lab=VDD}
N 2350 -13970 2350 -13940 {lab=VSS}
N 2350 -13940 2590 -13940 {lab=VSS}
N 2390 -13960 2640 -13960 {lab=VSS}
N 2390 -13970 2390 -13960 {lab=VSS}
N 2350 -13920 2570 -13920 {lab=VDD}
N 2390 -13900 2390 -13890 {lab=VDD}
N 2350 -13920 2350 -13890 {lab=VDD}
N 2390 -13900 2620 -13900 {lab=VDD}
N 2390 -13750 2390 -13740 {lab=VSS}
N 2390 -13740 2640 -13740 {lab=VSS}
N 2350 -13750 2350 -13720 {lab=VSS}
N 2350 -13720 2590 -13720 {lab=VSS}
N 2150 -14040 2510 -14040 {lab=TOFILL9_PAD}
N 2350 -14580 2570 -14580 {lab=VDD}
N 2390 -14560 2390 -14550 {lab=VDD}
N 2350 -14580 2350 -14550 {lab=VDD}
N 2390 -14560 2620 -14560 {lab=VDD}
N 2350 -14410 2350 -14380 {lab=VSS}
N 2350 -14380 2590 -14380 {lab=VSS}
N 2390 -14400 2640 -14400 {lab=VSS}
N 2390 -14410 2390 -14400 {lab=VSS}
N 2350 -14360 2570 -14360 {lab=VDD}
N 2390 -14340 2390 -14330 {lab=VDD}
N 2350 -14360 2350 -14330 {lab=VDD}
N 2390 -14340 2620 -14340 {lab=VDD}
N 2390 -14190 2390 -14180 {lab=VSS}
N 2390 -14180 2640 -14180 {lab=VSS}
N 2350 -14190 2350 -14160 {lab=VSS}
N 2350 -14160 2590 -14160 {lab=VSS}
N 2150 -14480 2510 -14480 {lab=TOFILL8_PAD}
N 2350 -15020 2570 -15020 {lab=VDD}
N 2390 -15000 2390 -14990 {lab=VDD}
N 2350 -15020 2350 -14990 {lab=VDD}
N 2390 -15000 2620 -15000 {lab=VDD}
N 2350 -14850 2350 -14820 {lab=VSS}
N 2350 -14820 2590 -14820 {lab=VSS}
N 2390 -14840 2640 -14840 {lab=VSS}
N 2390 -14850 2390 -14840 {lab=VSS}
N 2350 -14800 2570 -14800 {lab=VDD}
N 2390 -14780 2390 -14770 {lab=VDD}
N 2350 -14800 2350 -14770 {lab=VDD}
N 2390 -14780 2620 -14780 {lab=VDD}
N 2390 -14630 2390 -14620 {lab=VSS}
N 2390 -14620 2640 -14620 {lab=VSS}
N 2350 -14630 2350 -14600 {lab=VSS}
N 2350 -14600 2590 -14600 {lab=VSS}
N 2150 -14920 2510 -14920 {lab=GUARD_IMPORTANCE_TOP_GUARD_PAD}
N 2350 -15460 2570 -15460 {lab=VDD}
N 2390 -15440 2390 -15430 {lab=VDD}
N 2350 -15460 2350 -15430 {lab=VDD}
N 2390 -15440 2620 -15440 {lab=VDD}
N 2350 -15290 2350 -15260 {lab=VSS}
N 2350 -15260 2590 -15260 {lab=VSS}
N 2390 -15280 2640 -15280 {lab=VSS}
N 2390 -15290 2390 -15280 {lab=VSS}
N 2350 -15240 2570 -15240 {lab=VDD}
N 2390 -15220 2390 -15210 {lab=VDD}
N 2350 -15240 2350 -15210 {lab=VDD}
N 2390 -15220 2620 -15220 {lab=VDD}
N 2390 -15070 2390 -15060 {lab=VSS}
N 2390 -15060 2640 -15060 {lab=VSS}
N 2350 -15070 2350 -15040 {lab=VSS}
N 2350 -15040 2590 -15040 {lab=VSS}
N 2150 -15360 2510 -15360 {lab=GUARD_IMPORTANCE_BOTTOM_GUARD_PAD}
N 2350 -15900 2570 -15900 {lab=VDD}
N 2390 -15880 2390 -15870 {lab=VDD}
N 2350 -15900 2350 -15870 {lab=VDD}
N 2390 -15880 2620 -15880 {lab=VDD}
N 2350 -15730 2350 -15700 {lab=VSS}
N 2350 -15700 2590 -15700 {lab=VSS}
N 2390 -15720 2640 -15720 {lab=VSS}
N 2390 -15730 2390 -15720 {lab=VSS}
N 2350 -15680 2570 -15680 {lab=VDD}
N 2390 -15660 2390 -15650 {lab=VDD}
N 2350 -15680 2350 -15650 {lab=VDD}
N 2390 -15660 2620 -15660 {lab=VDD}
N 2390 -15510 2390 -15500 {lab=VSS}
N 2390 -15500 2640 -15500 {lab=VSS}
N 2350 -15510 2350 -15480 {lab=VSS}
N 2350 -15480 2590 -15480 {lab=VSS}
N 2150 -15800 2510 -15800 {lab=GUARD_IMPORTANCE_SIDE_GUARD_PAD}
N 2350 -16340 2570 -16340 {lab=VDD}
N 2390 -16320 2390 -16310 {lab=VDD}
N 2350 -16340 2350 -16310 {lab=VDD}
N 2390 -16320 2620 -16320 {lab=VDD}
N 2350 -16170 2350 -16140 {lab=VSS}
N 2350 -16140 2590 -16140 {lab=VSS}
N 2390 -16160 2640 -16160 {lab=VSS}
N 2390 -16170 2390 -16160 {lab=VSS}
N 2350 -16120 2570 -16120 {lab=VDD}
N 2390 -16100 2390 -16090 {lab=VDD}
N 2350 -16120 2350 -16090 {lab=VDD}
N 2390 -16100 2620 -16100 {lab=VDD}
N 2390 -15950 2390 -15940 {lab=VSS}
N 2390 -15940 2640 -15940 {lab=VSS}
N 2350 -15950 2350 -15920 {lab=VSS}
N 2350 -15920 2590 -15920 {lab=VSS}
N 2350 -16780 2570 -16780 {lab=VDD}
N 2390 -16760 2390 -16750 {lab=VDD}
N 2350 -16780 2350 -16750 {lab=VDD}
N 2390 -16760 2620 -16760 {lab=VDD}
N 2350 -16610 2350 -16580 {lab=VSS}
N 2350 -16580 2590 -16580 {lab=VSS}
N 2390 -16600 2640 -16600 {lab=VSS}
N 2390 -16610 2390 -16600 {lab=VSS}
N 2350 -16560 2570 -16560 {lab=VDD}
N 2390 -16540 2390 -16530 {lab=VDD}
N 2350 -16560 2350 -16530 {lab=VDD}
N 2390 -16540 2620 -16540 {lab=VDD}
N 2390 -16390 2390 -16380 {lab=VSS}
N 2390 -16380 2640 -16380 {lab=VSS}
N 2350 -16390 2350 -16360 {lab=VSS}
N 2350 -16360 2590 -16360 {lab=VSS}
N 2150 -16680 2510 -16680 {lab=GUARD_IMPORTANCE_PAD_GUARD_PAD}
N 2350 -17000 2570 -17000 {lab=VDD}
N 2390 -16980 2390 -16970 {lab=VDD}
N 2350 -17000 2350 -16970 {lab=VDD}
N 2390 -16980 2620 -16980 {lab=VDD}
N 2390 -16830 2390 -16820 {lab=VSS}
N 2390 -16820 2640 -16820 {lab=VSS}
N 2350 -16830 2350 -16800 {lab=VSS}
N 2350 -16800 2590 -16800 {lab=VSS}
N 2620 -17720 2620 -17640 {lab=VDD}
N 2570 -17770 2570 -17660 {lab=VDD}
N 7640 -15710 7640 -15680 {lab=VDD}
N 7420 -15680 7640 -15680 {lab=VDD}
N 7600 -15710 7600 -15700 {lab=VDD}
N 7370 -15700 7600 -15700 {lab=VDD}
N 7640 -15880 7640 -15850 {lab=VSS}
N 7400 -15880 7640 -15880 {lab=VSS}
N 7350 -15860 7600 -15860 {lab=VSS}
N 7600 -15860 7600 -15850 {lab=VSS}
N 7480 -15780 7840 -15780 {lab=TOFILL49_PAD}
N 7640 -15270 7640 -15240 {lab=VDD}
N 7420 -15240 7640 -15240 {lab=VDD}
N 7600 -15270 7600 -15260 {lab=VDD}
N 7370 -15260 7600 -15260 {lab=VDD}
N 7640 -15440 7640 -15410 {lab=VSS}
N 7400 -15440 7640 -15440 {lab=VSS}
N 7350 -15420 7600 -15420 {lab=VSS}
N 7600 -15420 7600 -15410 {lab=VSS}
N 7640 -15490 7640 -15460 {lab=VDD}
N 7420 -15460 7640 -15460 {lab=VDD}
N 7600 -15490 7600 -15480 {lab=VDD}
N 7370 -15480 7600 -15480 {lab=VDD}
N 7600 -15640 7600 -15630 {lab=VSS}
N 7350 -15640 7600 -15640 {lab=VSS}
N 7640 -15660 7640 -15630 {lab=VSS}
N 7400 -15660 7640 -15660 {lab=VSS}
N 7480 -15340 7840 -15340 {lab=TOFILL48_PAD}
N 7640 -14830 7640 -14800 {lab=VDD}
N 7420 -14800 7640 -14800 {lab=VDD}
N 7600 -14830 7600 -14820 {lab=VDD}
N 7370 -14820 7600 -14820 {lab=VDD}
N 7640 -15000 7640 -14970 {lab=VSS}
N 7400 -15000 7640 -15000 {lab=VSS}
N 7350 -14980 7600 -14980 {lab=VSS}
N 7600 -14980 7600 -14970 {lab=VSS}
N 7640 -15050 7640 -15020 {lab=VDD}
N 7420 -15020 7640 -15020 {lab=VDD}
N 7600 -15050 7600 -15040 {lab=VDD}
N 7370 -15040 7600 -15040 {lab=VDD}
N 7600 -15200 7600 -15190 {lab=VSS}
N 7350 -15200 7600 -15200 {lab=VSS}
N 7640 -15220 7640 -15190 {lab=VSS}
N 7400 -15220 7640 -15220 {lab=VSS}
N 7480 -14900 7840 -14900 {lab=TOFILL47_PAD}
N 7640 -14390 7640 -14360 {lab=VDD}
N 7420 -14360 7640 -14360 {lab=VDD}
N 7600 -14390 7600 -14380 {lab=VDD}
N 7370 -14380 7600 -14380 {lab=VDD}
N 7640 -14560 7640 -14530 {lab=VSS}
N 7400 -14560 7640 -14560 {lab=VSS}
N 7350 -14540 7600 -14540 {lab=VSS}
N 7600 -14540 7600 -14530 {lab=VSS}
N 7640 -14610 7640 -14580 {lab=VDD}
N 7420 -14580 7640 -14580 {lab=VDD}
N 7600 -14610 7600 -14600 {lab=VDD}
N 7370 -14600 7600 -14600 {lab=VDD}
N 7600 -14760 7600 -14750 {lab=VSS}
N 7350 -14760 7600 -14760 {lab=VSS}
N 7640 -14780 7640 -14750 {lab=VSS}
N 7400 -14780 7640 -14780 {lab=VSS}
N 7480 -14460 7840 -14460 {lab=TOFILL46_PAD}
N 7640 -13950 7640 -13920 {lab=VDD}
N 7420 -13920 7640 -13920 {lab=VDD}
N 7600 -13950 7600 -13940 {lab=VDD}
N 7370 -13940 7600 -13940 {lab=VDD}
N 7640 -14120 7640 -14090 {lab=VSS}
N 7400 -14120 7640 -14120 {lab=VSS}
N 7350 -14100 7600 -14100 {lab=VSS}
N 7600 -14100 7600 -14090 {lab=VSS}
N 7640 -14170 7640 -14140 {lab=VDD}
N 7420 -14140 7640 -14140 {lab=VDD}
N 7600 -14170 7600 -14160 {lab=VDD}
N 7370 -14160 7600 -14160 {lab=VDD}
N 7600 -14320 7600 -14310 {lab=VSS}
N 7350 -14320 7600 -14320 {lab=VSS}
N 7640 -14340 7640 -14310 {lab=VSS}
N 7400 -14340 7640 -14340 {lab=VSS}
N 7480 -14020 7840 -14020 {lab=TOFILL45_PAD}
N 7640 -13510 7640 -13480 {lab=VDD}
N 7420 -13480 7640 -13480 {lab=VDD}
N 7600 -13510 7600 -13500 {lab=VDD}
N 7370 -13500 7600 -13500 {lab=VDD}
N 7640 -13680 7640 -13650 {lab=VSS}
N 7400 -13680 7640 -13680 {lab=VSS}
N 7350 -13660 7600 -13660 {lab=VSS}
N 7600 -13660 7600 -13650 {lab=VSS}
N 7640 -13730 7640 -13700 {lab=VDD}
N 7420 -13700 7640 -13700 {lab=VDD}
N 7600 -13730 7600 -13720 {lab=VDD}
N 7370 -13720 7600 -13720 {lab=VDD}
N 7600 -13880 7600 -13870 {lab=VSS}
N 7350 -13880 7600 -13880 {lab=VSS}
N 7640 -13900 7640 -13870 {lab=VSS}
N 7400 -13900 7640 -13900 {lab=VSS}
N 7480 -13580 7840 -13580 {lab=TOFILL44_PAD}
N 7640 -13070 7640 -13040 {lab=VDD}
N 7420 -13040 7640 -13040 {lab=VDD}
N 7600 -13070 7600 -13060 {lab=VDD}
N 7370 -13060 7600 -13060 {lab=VDD}
N 7640 -13240 7640 -13210 {lab=VSS}
N 7400 -13240 7640 -13240 {lab=VSS}
N 7350 -13220 7600 -13220 {lab=VSS}
N 7600 -13220 7600 -13210 {lab=VSS}
N 7640 -13290 7640 -13260 {lab=VDD}
N 7420 -13260 7640 -13260 {lab=VDD}
N 7600 -13290 7600 -13280 {lab=VDD}
N 7370 -13280 7600 -13280 {lab=VDD}
N 7600 -13440 7600 -13430 {lab=VSS}
N 7350 -13440 7600 -13440 {lab=VSS}
N 7640 -13460 7640 -13430 {lab=VSS}
N 7400 -13460 7640 -13460 {lab=VSS}
N 7480 -13140 7840 -13140 {lab=TOFILL43_PAD}
N 7640 -12630 7640 -12600 {lab=VDD}
N 7420 -12600 7640 -12600 {lab=VDD}
N 7600 -12630 7600 -12620 {lab=VDD}
N 7370 -12620 7600 -12620 {lab=VDD}
N 7640 -12800 7640 -12770 {lab=VSS}
N 7400 -12800 7640 -12800 {lab=VSS}
N 7350 -12780 7600 -12780 {lab=VSS}
N 7600 -12780 7600 -12770 {lab=VSS}
N 7640 -12850 7640 -12820 {lab=VDD}
N 7420 -12820 7640 -12820 {lab=VDD}
N 7600 -12850 7600 -12840 {lab=VDD}
N 7370 -12840 7600 -12840 {lab=VDD}
N 7600 -13000 7600 -12990 {lab=VSS}
N 7350 -13000 7600 -13000 {lab=VSS}
N 7640 -13020 7640 -12990 {lab=VSS}
N 7400 -13020 7640 -13020 {lab=VSS}
N 7480 -12700 7840 -12700 {lab=TOFILL42_PAD}
N 7640 -12190 7640 -12160 {lab=VDD}
N 7420 -12160 7640 -12160 {lab=VDD}
N 7600 -12190 7600 -12180 {lab=VDD}
N 7370 -12180 7600 -12180 {lab=VDD}
N 7640 -12360 7640 -12330 {lab=VSS}
N 7400 -12360 7640 -12360 {lab=VSS}
N 7350 -12340 7600 -12340 {lab=VSS}
N 7600 -12340 7600 -12330 {lab=VSS}
N 7640 -12410 7640 -12380 {lab=VDD}
N 7420 -12380 7640 -12380 {lab=VDD}
N 7600 -12410 7600 -12400 {lab=VDD}
N 7370 -12400 7600 -12400 {lab=VDD}
N 7600 -12560 7600 -12550 {lab=VSS}
N 7350 -12560 7600 -12560 {lab=VSS}
N 7640 -12580 7640 -12550 {lab=VSS}
N 7400 -12580 7640 -12580 {lab=VSS}
N 7480 -12260 7840 -12260 {lab=TOFILL41_PAD}
N 7640 -11750 7640 -11720 {lab=VDD}
N 7420 -11720 7640 -11720 {lab=VDD}
N 7600 -11750 7600 -11740 {lab=VDD}
N 7370 -11740 7600 -11740 {lab=VDD}
N 7640 -11920 7640 -11890 {lab=VSS}
N 7400 -11920 7640 -11920 {lab=VSS}
N 7350 -11900 7600 -11900 {lab=VSS}
N 7600 -11900 7600 -11890 {lab=VSS}
N 7640 -11970 7640 -11940 {lab=VDD}
N 7420 -11940 7640 -11940 {lab=VDD}
N 7600 -11970 7600 -11960 {lab=VDD}
N 7370 -11960 7600 -11960 {lab=VDD}
N 7600 -12120 7600 -12110 {lab=VSS}
N 7350 -12120 7600 -12120 {lab=VSS}
N 7640 -12140 7640 -12110 {lab=VSS}
N 7400 -12140 7640 -12140 {lab=VSS}
N 7480 -11820 7840 -11820 {lab=TOFILL40_PAD}
N 7640 -11310 7640 -11280 {lab=VDD}
N 7420 -11280 7640 -11280 {lab=VDD}
N 7600 -11310 7600 -11300 {lab=VDD}
N 7370 -11300 7600 -11300 {lab=VDD}
N 7640 -11480 7640 -11450 {lab=VSS}
N 7400 -11480 7640 -11480 {lab=VSS}
N 7350 -11460 7600 -11460 {lab=VSS}
N 7600 -11460 7600 -11450 {lab=VSS}
N 7640 -11530 7640 -11500 {lab=VDD}
N 7420 -11500 7640 -11500 {lab=VDD}
N 7600 -11530 7600 -11520 {lab=VDD}
N 7370 -11520 7600 -11520 {lab=VDD}
N 7600 -11680 7600 -11670 {lab=VSS}
N 7350 -11680 7600 -11680 {lab=VSS}
N 7640 -11700 7640 -11670 {lab=VSS}
N 7400 -11700 7640 -11700 {lab=VSS}
N 7480 -11380 7840 -11380 {lab=TOFILL39_PAD}
N 7640 -10870 7640 -10840 {lab=VDD}
N 7420 -10840 7640 -10840 {lab=VDD}
N 7600 -10870 7600 -10860 {lab=VDD}
N 7370 -10860 7600 -10860 {lab=VDD}
N 7640 -11040 7640 -11010 {lab=VSS}
N 7400 -11040 7640 -11040 {lab=VSS}
N 7350 -11020 7600 -11020 {lab=VSS}
N 7600 -11020 7600 -11010 {lab=VSS}
N 7640 -11090 7640 -11060 {lab=VDD}
N 7420 -11060 7640 -11060 {lab=VDD}
N 7600 -11090 7600 -11080 {lab=VDD}
N 7370 -11080 7600 -11080 {lab=VDD}
N 7600 -11240 7600 -11230 {lab=VSS}
N 7350 -11240 7600 -11240 {lab=VSS}
N 7640 -11260 7640 -11230 {lab=VSS}
N 7400 -11260 7640 -11260 {lab=VSS}
N 7480 -10940 7840 -10940 {lab=TOFILL38_PAD}
N 7640 -10430 7640 -10400 {lab=VDD}
N 7420 -10400 7640 -10400 {lab=VDD}
N 7600 -10430 7600 -10420 {lab=VDD}
N 7370 -10420 7600 -10420 {lab=VDD}
N 7640 -10600 7640 -10570 {lab=VSS}
N 7400 -10600 7640 -10600 {lab=VSS}
N 7350 -10580 7600 -10580 {lab=VSS}
N 7600 -10580 7600 -10570 {lab=VSS}
N 7640 -10650 7640 -10620 {lab=VDD}
N 7420 -10620 7640 -10620 {lab=VDD}
N 7600 -10650 7600 -10640 {lab=VDD}
N 7370 -10640 7600 -10640 {lab=VDD}
N 7600 -10800 7600 -10790 {lab=VSS}
N 7350 -10800 7600 -10800 {lab=VSS}
N 7640 -10820 7640 -10790 {lab=VSS}
N 7400 -10820 7640 -10820 {lab=VSS}
N 7480 -10500 7840 -10500 {lab=TOFILL37_PAD}
N 7640 -9990 7640 -9960 {lab=VDD}
N 7420 -9960 7640 -9960 {lab=VDD}
N 7600 -9990 7600 -9980 {lab=VDD}
N 7370 -9980 7600 -9980 {lab=VDD}
N 7640 -10160 7640 -10130 {lab=VSS}
N 7400 -10160 7640 -10160 {lab=VSS}
N 7350 -10140 7600 -10140 {lab=VSS}
N 7600 -10140 7600 -10130 {lab=VSS}
N 7640 -10210 7640 -10180 {lab=VDD}
N 7420 -10180 7640 -10180 {lab=VDD}
N 7600 -10210 7600 -10200 {lab=VDD}
N 7370 -10200 7600 -10200 {lab=VDD}
N 7600 -10360 7600 -10350 {lab=VSS}
N 7350 -10360 7600 -10360 {lab=VSS}
N 7640 -10380 7640 -10350 {lab=VSS}
N 7400 -10380 7640 -10380 {lab=VSS}
N 7480 -10060 7840 -10060 {lab=TOFILL36_PAD}
N 7640 -8010 7640 -7980 {lab=VDD}
N 7420 -7980 7640 -7980 {lab=VDD}
N 7600 -8010 7600 -8000 {lab=VDD}
N 7370 -8000 7600 -8000 {lab=VDD}
N 7600 -8160 7600 -8150 {lab=VSS}
N 7350 -8160 7600 -8160 {lab=VSS}
N 7640 -8180 7640 -8150 {lab=VSS}
N 7400 -8180 7640 -8180 {lab=VSS}
N 7350 -7280 7350 -7060 {lab=VSS}
N 7370 -7340 7370 -7120 {lab=VDD}
N 7400 -7300 7400 -7080 {lab=VSS}
N 7420 -7320 7420 -7100 {lab=VDD}
N 7640 -7340 7640 -7320 {lab=VDD}
N 7420 -7320 7640 -7320 {lab=VDD}
N 7370 -7340 7640 -7340 {lab=VDD}
N 7640 -7520 7640 -7490 {lab=VSS}
N 7400 -7520 7640 -7520 {lab=VSS}
N 7350 -7500 7600 -7500 {lab=VSS}
N 7640 -7350 7840 -7350 {lab=VDD}
N 7840 -7420 7850 -7420 {lab=VDD}
N 7840 -7420 7840 -7350 {lab=VDD}
N 7600 -7500 7600 -7490 {lab=VSS}
N 7640 -7790 7640 -7760 {lab=VDD}
N 7420 -7760 7640 -7760 {lab=VDD}
N 7600 -7790 7600 -7780 {lab=VDD}
N 7370 -7780 7600 -7780 {lab=VDD}
N 7640 -7940 7640 -7930 {lab=VSS}
N 7400 -7960 7640 -7960 {lab=VSS}
N 7350 -7940 7640 -7940 {lab=VSS}
N 7640 -7940 7840 -7940 {lab=VSS}
N 7840 -7940 7840 -7860 {lab=VSS}
N 7840 -7860 7850 -7860 {lab=VSS}
N 7640 -7570 7640 -7540 {lab=VDD}
N 7420 -7540 7640 -7540 {lab=VDD}
N 7600 -7570 7600 -7560 {lab=VDD}
N 7370 -7560 7600 -7560 {lab=VDD}
N 7600 -7720 7600 -7710 {lab=VSS}
N 7350 -7720 7600 -7720 {lab=VSS}
N 7640 -7740 7640 -7710 {lab=VSS}
N 7400 -7740 7640 -7740 {lab=VSS}
N 2700 -1280 3320 -1280 {lab=CHARGE_PUMP_GUARD_PAD}
N 3320 -2200 3320 -1280 {lab=CHARGE_PUMP_GUARD_PAD}
N 3100 -2200 3320 -2200 {lab=CHARGE_PUMP_GUARD_PAD}
N 2700 -2180 2700 -1280 {lab=CHARGE_PUMP_GUARD_PAD}
N 2140 -2160 2210 -2160 {lab=CHARGE_PUMP_VS_PAD}
N 2510 -2180 2700 -2180 {lab=CHARGE_PUMP_GUARD_PAD}
N 2510 -2160 2740 -2160 {lab=CHARGE_PUMP_VS_PAD}
N 2740 -2230 2740 -2160 {lab=CHARGE_PUMP_VS_PAD}
N 2740 -2230 2950 -2230 {lab=CHARGE_PUMP_VS_PAD}
N 3100 -2160 3160 -2160 {lab=CHARGE_PUMP_G2_PAD}
N 2150 -3040 2210 -3040 {lab=CHARGE_PUMP_VW_PAD}
N 2700 -3060 2700 -2180 {lab=CHARGE_PUMP_GUARD_PAD}
N 2510 -3060 2700 -3060 {lab=CHARGE_PUMP_GUARD_PAD}
N 2510 -3040 2750 -3040 {lab=CHARGE_PUMP_VW_PAD}
N 2750 -3040 2750 -2090 {lab=CHARGE_PUMP_VW_PAD}
N 2750 -2090 2950 -2090 {lab=CHARGE_PUMP_VW_PAD}
N 3160 -2160 3160 -1720 {lab=CHARGE_PUMP_G2_PAD}
N 2800 -2600 2800 -2160 {lab=CHARGE_PUMP_G1_PAD}
N 7640 -7130 7640 -7100 {lab=VDD}
N 7420 -7100 7640 -7100 {lab=VDD}
N 7600 -7130 7600 -7120 {lab=VDD}
N 7370 -7120 7600 -7120 {lab=VDD}
N 7350 -7280 7600 -7280 {lab=VSS}
N 7600 -7280 7600 -7270 {lab=VSS}
N 2350 -7960 2350 -7950 {lab=VDD}
N 2350 -7980 2570 -7980 {lab=VDD}
N 2350 -7980 2350 -7960 {lab=VDD}
N 2350 -7810 2350 -7780 {lab=VSS}
N 2350 -7780 2590 -7780 {lab=VSS}
N 2390 -7800 2640 -7800 {lab=VSS}
N 2150 -7950 2350 -7950 {lab=VDD}
N 2140 -7880 2150 -7880 {lab=VDD}
N 2150 -7950 2150 -7880 {lab=VDD}
N 2350 -7960 2620 -7960 {lab=VDD}
N 2390 -7810 2390 -7800 {lab=VSS}
N 2350 -7540 2570 -7540 {lab=VDD}
N 2390 -7520 2390 -7510 {lab=VDD}
N 2350 -7540 2350 -7510 {lab=VDD}
N 2390 -7520 2620 -7520 {lab=VDD}
N 2350 -7360 2350 -7340 {lab=VSS}
N 2350 -7340 2590 -7340 {lab=VSS}
N 2350 -7360 2640 -7360 {lab=VSS}
N 2150 -7360 2350 -7360 {lab=VSS}
N 2150 -7440 2150 -7360 {lab=VSS}
N 2140 -7440 2150 -7440 {lab=VSS}
N 6480 -200 6480 20 {lab=VDD}
N 6500 -20 6510 -20 {lab=VDD}
N 6480 20 6510 20 {lab=VDD}
N 6500 -250 6500 -20 {lab=VDD}
N 6650 20 6680 20 {lab=VSS}
N 6680 -220 6680 20 {lab=VSS}
N 6650 -20 6660 -20 {lab=VSS}
N 6660 -270 6660 -20 {lab=VSS}
N 6040 -200 6040 20 {lab=VDD}
N 6060 -20 6070 -20 {lab=VDD}
N 6040 20 6070 20 {lab=VDD}
N 6060 -250 6060 -20 {lab=VDD}
N 6210 -20 6220 -20 {lab=VSS}
N 6220 -270 6220 -20 {lab=VSS}
N 6210 20 6240 20 {lab=VSS}
N 6240 -220 6240 20 {lab=VSS}
N 5820 -200 5820 20 {lab=VDD}
N 5840 -20 5850 -20 {lab=VDD}
N 5820 20 5850 20 {lab=VDD}
N 5840 -250 5840 -20 {lab=VDD}
N 5990 20 6020 20 {lab=VSS}
N 6020 -220 6020 20 {lab=VSS}
N 5990 -20 6000 -20 {lab=VSS}
N 6000 -270 6000 -20 {lab=VSS}
N 5600 -200 5600 20 {lab=VDD}
N 5620 -20 5630 -20 {lab=VDD}
N 5600 20 5630 20 {lab=VDD}
N 5620 -250 5620 -20 {lab=VDD}
N 5770 20 5800 20 {lab=VSS}
N 5800 -220 5800 20 {lab=VSS}
N 5770 -20 5780 -20 {lab=VSS}
N 5780 -270 5780 -20 {lab=VSS}
N 4620 -200 4620 20 {lab=VDD}
N 4640 -20 4650 -20 {lab=VDD}
N 4620 20 4650 20 {lab=VDD}
N 4640 -250 4640 -20 {lab=VDD}
N 4790 20 4820 20 {lab=VSS}
N 4820 -220 4820 20 {lab=VSS}
N 4800 -270 4800 -20 {lab=VSS}
N 4790 -20 4800 -20 {lab=VSS}
N 4720 160 4720 220 {lab=ASIG_GUARD_PAD}
N 4740 -320 4740 -140 {lab=PAD_GUARD_PAD}
N 4720 -400 4720 -140 {lab=#net3}
N 4400 -200 4400 20 {lab=VDD}
N 4420 -20 4430 -20 {lab=VDD}
N 4400 20 4430 20 {lab=VDD}
N 4420 -250 4420 -20 {lab=VDD}
N 4570 20 4600 20 {lab=VSS}
N 4600 -220 4600 20 {lab=VSS}
N 4570 -20 4580 -20 {lab=VSS}
N 4580 -270 4580 -20 {lab=VSS}
N 4180 -200 4180 20 {lab=VDD}
N 4200 -20 4210 -20 {lab=VDD}
N 4180 20 4210 20 {lab=VDD}
N 4200 -250 4200 -20 {lab=VDD}
N 4350 -20 4360 -20 {lab=VSS}
N 4360 -270 4360 -20 {lab=VSS}
N 4350 20 4380 20 {lab=VSS}
N 4380 -220 4380 20 {lab=VSS}
N 3620 -320 3620 220 {lab=PAD_GUARD_PAD}
N 3620 -320 4740 -320 {lab=PAD_GUARD_PAD}
N 2570 -7320 2570 -7100 {lab=VDD}
N 2590 -7340 2590 -7120 {lab=VSS}
N 2620 -7300 2620 -7080 {lab=VDD}
N 2640 -7360 2640 -7140 {lab=VSS}
N 7640 -16590 7640 -16560 {lab=VDD}
N 7420 -16560 7640 -16560 {lab=VDD}
N 7600 -16590 7600 -16580 {lab=VDD}
N 7370 -16580 7600 -16580 {lab=VDD}
N 7640 -16760 7640 -16730 {lab=VSS}
N 7400 -16760 7640 -16760 {lab=VSS}
N 7350 -16740 7600 -16740 {lab=VSS}
N 7600 -16740 7600 -16730 {lab=VSS}
N 7640 -16810 7640 -16780 {lab=VDD}
N 7420 -16780 7640 -16780 {lab=VDD}
N 7600 -16810 7600 -16800 {lab=VDD}
N 7370 -16800 7600 -16800 {lab=VDD}
N 7600 -16960 7600 -16950 {lab=VSS}
N 7350 -16960 7600 -16960 {lab=VSS}
N 7640 -16980 7640 -16950 {lab=VSS}
N 7400 -16980 7640 -16980 {lab=VSS}
N 7480 -16660 7840 -16660 {lab=TOFILL51_PAD}
N 7640 -16150 7640 -16120 {lab=VDD}
N 7420 -16120 7640 -16120 {lab=VDD}
N 7600 -16150 7600 -16140 {lab=VDD}
N 7370 -16140 7600 -16140 {lab=VDD}
N 7640 -16320 7640 -16290 {lab=VSS}
N 7400 -16320 7640 -16320 {lab=VSS}
N 7350 -16300 7600 -16300 {lab=VSS}
N 7600 -16300 7600 -16290 {lab=VSS}
N 7640 -16370 7640 -16340 {lab=VDD}
N 7420 -16340 7640 -16340 {lab=VDD}
N 7600 -16370 7600 -16360 {lab=VDD}
N 7370 -16360 7600 -16360 {lab=VDD}
N 7600 -16520 7600 -16510 {lab=VSS}
N 7350 -16520 7600 -16520 {lab=VSS}
N 7640 -16540 7640 -16510 {lab=VSS}
N 7400 -16540 7640 -16540 {lab=VSS}
N 7480 -16220 7840 -16220 {lab=TOFILL50_PAD}
N 7640 -15930 7640 -15900 {lab=VDD}
N 7420 -15900 7640 -15900 {lab=VDD}
N 7600 -15930 7600 -15920 {lab=VDD}
N 7370 -15920 7600 -15920 {lab=VDD}
N 7600 -16080 7600 -16070 {lab=VSS}
N 7350 -16080 7600 -16080 {lab=VSS}
N 7640 -16100 7640 -16070 {lab=VSS}
N 7400 -16100 7640 -16100 {lab=VSS}
N 7420 -16120 7420 -15900 {lab=VDD}
N 7400 -16100 7400 -15880 {lab=VSS}
N 7370 -16140 7370 -15920 {lab=VDD}
N 7350 -16080 7350 -15860 {lab=VSS}
N 7640 -7080 7640 -7050 {lab=VSS}
N 7400 -7080 7640 -7080 {lab=VSS}
N 7640 -7300 7640 -7270 {lab=VSS}
N 7400 -7300 7640 -7300 {lab=VSS}
N 7140 -5900 7370 -5900 {lab=VDD}
N 7420 -1820 7420 -1600 {lab=VDD}
N 7370 -1840 7370 -1620 {lab=VDD}
N 7400 -2020 7400 -1800 {lab=VSS}
N 7350 -1940 7350 -1780 {lab=VSS}
N 7420 -2040 7420 -1820 {lab=VDD}
N 7370 -2060 7370 -1840 {lab=VDD}
N 7400 -2240 7400 -2020 {lab=VSS}
N 7350 -2220 7350 -2000 {lab=VSS}
N 7420 -2260 7420 -2040 {lab=VDD}
N 7370 -2280 7370 -2060 {lab=VDD}
N 7400 -2460 7400 -2240 {lab=VSS}
N 7350 -2440 7350 -2220 {lab=VSS}
N 7420 -2480 7420 -2260 {lab=VDD}
N 7370 -2500 7370 -2280 {lab=VDD}
N 7400 -2680 7400 -2460 {lab=VSS}
N 7350 -2660 7350 -2440 {lab=VSS}
N 7420 -2700 7420 -2480 {lab=VDD}
N 7370 -2720 7370 -2500 {lab=VDD}
N 7400 -2900 7400 -2680 {lab=VSS}
N 7350 -2880 7350 -2660 {lab=VSS}
N 7420 -2920 7420 -2700 {lab=VDD}
N 7370 -2940 7370 -2720 {lab=VDD}
N 7400 -3120 7400 -2900 {lab=VSS}
N 7350 -3100 7350 -2880 {lab=VSS}
N 7300 -2460 7300 -2120 {lab=guard_transistors_PAD}
N 7300 -2560 7300 -2460 {lab=guard_transistors_PAD}
N 7350 -2000 7350 -1940 {lab=VSS}
N 7420 -3140 7420 -2920 {lab=VDD}
N 7370 -3160 7370 -2940 {lab=VDD}
N 7400 -3340 7400 -3120 {lab=VSS}
N 7350 -3320 7350 -3100 {lab=VSS}
N 7420 -3360 7420 -3140 {lab=VDD}
N 7370 -3260 7370 -3160 {lab=VDD}
N 7400 -3560 7400 -3340 {lab=VSS}
N 7350 -3540 7350 -3320 {lab=VSS}
N 7420 -3580 7420 -3360 {lab=VDD}
N 7370 -3600 7370 -3380 {lab=VDD}
N 7400 -3780 7400 -3560 {lab=VSS}
N 7350 -3760 7350 -3540 {lab=VSS}
N 7420 -3800 7420 -3580 {lab=VDD}
N 7370 -3820 7370 -3600 {lab=VDD}
N 7400 -4000 7400 -3780 {lab=VSS}
N 7350 -3980 7350 -3760 {lab=VSS}
N 7420 -4020 7420 -3800 {lab=VDD}
N 7370 -4040 7370 -3820 {lab=VDD}
N 7400 -4220 7400 -4000 {lab=VSS}
N 7350 -4200 7350 -3980 {lab=VSS}
N 7420 -4240 7420 -4020 {lab=VDD}
N 7370 -4260 7370 -4040 {lab=VDD}
N 7400 -4440 7400 -4220 {lab=VSS}
N 7350 -4420 7350 -4200 {lab=VSS}
N 7300 -3780 7300 -3440 {lab=guard_transistors_PAD}
N 7300 -3880 7300 -3780 {lab=guard_transistors_PAD}
N 7420 -4460 7420 -4240 {lab=VDD}
N 7370 -4480 7370 -4260 {lab=VDD}
N 7400 -4660 7400 -4440 {lab=VSS}
N 7350 -4580 7350 -4420 {lab=VSS}
N 7420 -4680 7420 -4460 {lab=VDD}
N 7370 -4700 7370 -4480 {lab=VDD}
N 7400 -4880 7400 -4660 {lab=VSS}
N 7350 -4860 7350 -4640 {lab=VSS}
N 7420 -4900 7420 -4680 {lab=VDD}
N 7370 -4920 7370 -4700 {lab=VDD}
N 7400 -5100 7400 -4880 {lab=VSS}
N 7350 -5080 7350 -4860 {lab=VSS}
N 7420 -5120 7420 -4900 {lab=VDD}
N 7370 -5140 7370 -4920 {lab=VDD}
N 7400 -5320 7400 -5100 {lab=VSS}
N 7350 -5300 7350 -5080 {lab=VSS}
N 7420 -5340 7420 -5120 {lab=VDD}
N 7370 -5360 7370 -5140 {lab=VDD}
N 7400 -5540 7400 -5320 {lab=VSS}
N 7350 -5520 7350 -5300 {lab=VSS}
N 7420 -5560 7420 -5340 {lab=VDD}
N 7370 -5580 7370 -5360 {lab=VDD}
N 7400 -5760 7400 -5540 {lab=VSS}
N 7350 -5740 7350 -5520 {lab=VSS}
N 7300 -5100 7300 -4760 {lab=guard_transistors_PAD}
N 7300 -5200 7300 -5100 {lab=guard_transistors_PAD}
N 7350 -4640 7350 -4580 {lab=VSS}
N 7370 -3380 7370 -3260 {lab=VDD}
N 7420 -5780 7420 -5560 {lab=VDD}
N 7370 -5800 7370 -5580 {lab=VDD}
N 7400 -5980 7400 -5760 {lab=VSS}
N 7350 -5960 7350 -5740 {lab=VSS}
N 7420 -6000 7420 -5780 {lab=VDD}
N 7370 -5900 7370 -5800 {lab=VDD}
N 7400 -6200 7400 -5980 {lab=VSS}
N 7350 -6180 7350 -5960 {lab=VSS}
N 7420 -6220 7420 -6000 {lab=VDD}
N 7370 -6240 7370 -6020 {lab=VDD}
N 7400 -6420 7400 -6200 {lab=VSS}
N 7350 -6400 7350 -6180 {lab=VSS}
N 7420 -6440 7420 -6220 {lab=VDD}
N 7370 -6460 7370 -6240 {lab=VDD}
N 7400 -6640 7400 -6420 {lab=VSS}
N 7350 -6620 7350 -6400 {lab=VSS}
N 7420 -6660 7420 -6440 {lab=VDD}
N 7370 -6680 7370 -6460 {lab=VDD}
N 7400 -6860 7400 -6640 {lab=VSS}
N 7350 -6840 7350 -6620 {lab=VSS}
N 7420 -6880 7420 -6660 {lab=VDD}
N 7370 -6900 7370 -6680 {lab=VDD}
N 7400 -7080 7400 -6860 {lab=VSS}
N 7350 -7060 7350 -6840 {lab=VSS}
N 7300 -6420 7300 -6080 {lab=guard_transistors_PAD}
N 7300 -6520 7300 -6420 {lab=guard_transistors_PAD}
N 7420 -7100 7420 -6880 {lab=VDD}
N 7370 -7120 7370 -6900 {lab=VDD}
N 7120 -220 7340 -220 {lab=VSS}
N 7100 -270 7320 -270 {lab=VSS}
N 7400 -700 7400 -480 {lab=VSS}
N 7350 -680 7350 -460 {lab=VSS}
N 7640 -310 7640 -300 {lab=VDD}
N 7420 -940 7420 -720 {lab=VDD}
N 7370 -960 7370 -740 {lab=VDD}
N 7400 -1140 7400 -920 {lab=VSS}
N 7350 -1120 7350 -900 {lab=VSS}
N 7640 -920 7640 -900 {lab=VSS}
N 5060 -200 5280 -200 {lab=VDD}
N 5080 -250 5300 -250 {lab=VDD}
N 5260 -220 5580 -220 {lab=VSS}
N 5240 -270 5560 -270 {lab=VSS}
N 3300 -200 3520 -200 {lab=VDD}
N 3320 -250 3540 -250 {lab=VDD}
N 3700 -270 3920 -270 {lab=VSS}
N 3720 -220 3940 -220 {lab=VSS}
N 3740 -200 3960 -200 {lab=VDD}
N 3760 -250 3980 -250 {lab=VDD}
N 3940 -220 4160 -220 {lab=VSS}
N 3920 -270 4140 -270 {lab=VSS}
N 4620 -200 4840 -200 {lab=VDD}
N 4640 -250 4860 -250 {lab=VDD}
N 4800 -270 5020 -270 {lab=VSS}
N 4820 -220 5040 -220 {lab=VSS}
N 6040 -200 6260 -200 {lab=VDD}
N 6060 -250 6280 -250 {lab=VDD}
N 6240 -220 6460 -220 {lab=VSS}
N 6220 -270 6440 -270 {lab=VSS}
N 6700 -200 6920 -200 {lab=VDD}
N 6720 -250 6940 -250 {lab=VDD}
N 6480 -200 6700 -200 {lab=VDD}
N 6500 -250 6720 -250 {lab=VDD}
N 6660 -270 6880 -270 {lab=VSS}
N 6680 -220 6900 -220 {lab=VSS}
N 2570 -700 2570 -480 {lab=VDD}
N 2620 -680 2620 -460 {lab=VDD}
N 2590 -500 2590 -280 {lab=VSS}
N 2640 -520 2640 -300 {lab=VSS}
N 2350 -310 2350 -300 {lab=VSS}
N 5430 -320 6340 -320 {lab=PAD_GUARD_PAD}
N 4740 -320 5430 -320 {lab=PAD_GUARD_PAD}
N 7420 -720 7420 -500 {lab=VDD}
N 7370 -740 7370 -520 {lab=VDD}
N 7350 -900 7350 -680 {lab=VSS}
N 7400 -920 7400 -700 {lab=VSS}
N 2570 -920 2570 -700 {lab=VDD}
N 2620 -900 2620 -680 {lab=VDD}
N 2640 -740 2640 -520 {lab=VSS}
N 2590 -720 2590 -500 {lab=VSS}
N 2570 -1160 2570 -920 {lab=VDD}
N 2620 -1140 2620 -900 {lab=VDD}
N 2590 -960 2590 -720 {lab=VSS}
N 2640 -980 2640 -740 {lab=VSS}
N 7420 -1160 7420 -940 {lab=VDD}
N 7370 -1180 7370 -960 {lab=VDD}
N 7350 -1340 7350 -1120 {lab=VSS}
N 7400 -1360 7400 -1140 {lab=VSS}
N 7420 -1380 7420 -1160 {lab=VDD}
N 7370 -1400 7370 -1180 {lab=VDD}
N 7400 -1580 7400 -1360 {lab=VSS}
N 7350 -1560 7350 -1340 {lab=VSS}
N 7420 -1600 7420 -1380 {lab=VDD}
N 7370 -1620 7370 -1400 {lab=VDD}
N 7350 -1780 7350 -1560 {lab=VSS}
N 7400 -1800 7400 -1580 {lab=VSS}
N 7040 -17720 7260 -17720 {lab=VDD}
N 6860 -17750 7080 -17750 {lab=VSS}
N 6880 -17700 7100 -17700 {lab=VSS}
N 6840 -17770 7020 -17770 {lab=VDD}
N 6820 -17720 7040 -17720 {lab=VDD}
N 6640 -17750 6860 -17750 {lab=VSS}
N 6660 -17700 6880 -17700 {lab=VSS}
N 6620 -17770 6840 -17770 {lab=VDD}
N 6600 -17720 6820 -17720 {lab=VDD}
N 6440 -17700 6660 -17700 {lab=VSS}
N 6420 -17750 6640 -17750 {lab=VSS}
N 6340 -17720 6600 -17720 {lab=VDD}
N 6200 -17750 6420 -17750 {lab=VSS}
N 6220 -17700 6440 -17700 {lab=VSS}
N 6160 -17720 6340 -17720 {lab=VDD}
N 6000 -17700 6220 -17700 {lab=VSS}
N 5980 -17750 6200 -17750 {lab=VSS}
N 5960 -17770 6180 -17770 {lab=VDD}
N 5940 -17720 6160 -17720 {lab=VDD}
N 5760 -17750 5980 -17750 {lab=VSS}
N 5780 -17700 6000 -17700 {lab=VSS}
N 5720 -17720 5940 -17720 {lab=VDD}
N 5560 -17700 5780 -17700 {lab=VSS}
N 5540 -17750 5760 -17750 {lab=VSS}
N 5520 -17770 5680 -17770 {lab=VDD}
N 5500 -17720 5720 -17720 {lab=VDD}
N 5320 -17750 5540 -17750 {lab=VSS}
N 5340 -17700 5560 -17700 {lab=VSS}
N 5300 -17770 5520 -17770 {lab=VDD}
N 5280 -17720 5500 -17720 {lab=VDD}
N 5120 -17700 5340 -17700 {lab=VSS}
N 5100 -17750 5320 -17750 {lab=VSS}
N 5080 -17770 5300 -17770 {lab=VDD}
N 5060 -17720 5280 -17720 {lab=VDD}
N 4880 -17750 5100 -17750 {lab=VSS}
N 4900 -17700 5120 -17700 {lab=VSS}
N 4860 -17770 5080 -17770 {lab=VDD}
N 4840 -17720 5060 -17720 {lab=VDD}
N 4680 -17700 4900 -17700 {lab=VSS}
N 4660 -17750 4880 -17750 {lab=VSS}
N 4640 -17770 4860 -17770 {lab=VDD}
N 4620 -17720 4840 -17720 {lab=VDD}
N 4440 -17750 4660 -17750 {lab=VSS}
N 4460 -17700 4680 -17700 {lab=VSS}
N 4420 -17770 4640 -17770 {lab=VDD}
N 4400 -17720 4620 -17720 {lab=VDD}
N 4240 -17700 4460 -17700 {lab=VSS}
N 4220 -17750 4440 -17750 {lab=VSS}
N 4200 -17770 4420 -17770 {lab=VDD}
N 4180 -17720 4400 -17720 {lab=VDD}
N 4000 -17750 4220 -17750 {lab=VSS}
N 4020 -17700 4240 -17700 {lab=VSS}
N 3980 -17770 4200 -17770 {lab=VDD}
N 3960 -17720 4180 -17720 {lab=VDD}
N 3800 -17700 4020 -17700 {lab=VSS}
N 3780 -17750 4000 -17750 {lab=VSS}
N 3760 -17770 3980 -17770 {lab=VDD}
N 3740 -17720 3960 -17720 {lab=VDD}
N 3360 -17700 3580 -17700 {lab=VSS}
N 3340 -17750 3560 -17750 {lab=VSS}
N 3320 -17770 3540 -17770 {lab=VDD}
N 3300 -17720 3520 -17720 {lab=VDD}
N 3120 -17750 3340 -17750 {lab=VSS}
N 3140 -17700 3360 -17700 {lab=VSS}
N 3100 -17770 3320 -17770 {lab=VDD}
N 3080 -17720 3300 -17720 {lab=VDD}
N 2920 -17700 3140 -17700 {lab=VSS}
N 2900 -17750 3120 -17750 {lab=VSS}
N 2880 -17770 3100 -17770 {lab=VDD}
N 2860 -17720 3080 -17720 {lab=VDD}
N 2680 -17750 2900 -17750 {lab=VSS}
N 2700 -17700 2920 -17700 {lab=VSS}
N 2640 -17700 2700 -17700 {lab=VSS}
N 2590 -7120 2590 -6900 {lab=VSS}
N 2640 -7140 2640 -6920 {lab=VSS}
N 2570 -7100 2570 -6880 {lab=VDD}
N 2620 -7080 2620 -6860 {lab=VDD}
N 2640 -6920 2640 -6700 {lab=VSS}
N 2590 -6900 2590 -6680 {lab=VSS}
N 2570 -6880 2570 -6660 {lab=VDD}
N 2620 -6860 2620 -6640 {lab=VDD}
N 2590 -6680 2590 -6460 {lab=VSS}
N 2640 -6700 2640 -6480 {lab=VSS}
N 2570 -6660 2570 -6440 {lab=VDD}
N 2620 -6640 2620 -6420 {lab=VDD}
N 2640 -6480 2640 -6260 {lab=VSS}
N 2590 -6460 2590 -6240 {lab=VSS}
N 2570 -6440 2570 -6220 {lab=VDD}
N 2620 -6420 2620 -6200 {lab=VDD}
N 2590 -6240 2590 -6020 {lab=VSS}
N 2640 -6260 2640 -6040 {lab=VSS}
N 2570 -6220 2570 -6000 {lab=VDD}
N 2620 -6200 2620 -5980 {lab=VDD}
N 2640 -6040 2640 -5820 {lab=VSS}
N 2590 -6020 2590 -5800 {lab=VSS}
N 2570 -6000 2570 -5780 {lab=VDD}
N 2620 -5980 2620 -5760 {lab=VDD}
N 2590 -5800 2590 -5580 {lab=VSS}
N 2640 -5820 2640 -5600 {lab=VSS}
N 2570 -5780 2570 -5560 {lab=VDD}
N 2620 -5760 2620 -5540 {lab=VDD}
N 2640 -5600 2640 -5380 {lab=VSS}
N 2590 -5580 2590 -5360 {lab=VSS}
N 2570 -5560 2570 -5340 {lab=VDD}
N 2620 -5540 2620 -5320 {lab=VDD}
N 2590 -5360 2590 -5140 {lab=VSS}
N 2640 -5380 2640 -5160 {lab=VSS}
N 2570 -5340 2570 -5120 {lab=VDD}
N 2620 -5320 2620 -5100 {lab=VDD}
N 2640 -5160 2640 -4940 {lab=VSS}
N 2590 -5140 2590 -4920 {lab=VSS}
N 2570 -5120 2570 -4900 {lab=VDD}
N 2620 -5100 2620 -4880 {lab=VDD}
N 2590 -4920 2590 -4700 {lab=VSS}
N 2640 -4940 2640 -4720 {lab=VSS}
N 2570 -4900 2570 -4680 {lab=VDD}
N 2620 -4880 2620 -4660 {lab=VDD}
N 2640 -4720 2640 -4500 {lab=VSS}
N 2590 -4700 2590 -4480 {lab=VSS}
N 2570 -4680 2570 -4460 {lab=VDD}
N 2620 -4660 2620 -4440 {lab=VDD}
N 2590 -4480 2590 -4260 {lab=VSS}
N 2640 -4500 2640 -4280 {lab=VSS}
N 2570 -4460 2570 -4240 {lab=VDD}
N 2620 -4440 2620 -4220 {lab=VDD}
N 2640 -4280 2640 -4060 {lab=VSS}
N 2590 -4260 2590 -4040 {lab=VSS}
N 2570 -4240 2570 -4020 {lab=VDD}
N 2620 -4220 2620 -4000 {lab=VDD}
N 2590 -4040 2590 -3820 {lab=VSS}
N 2640 -4060 2640 -3840 {lab=VSS}
N 2570 -4020 2570 -3800 {lab=VDD}
N 2620 -4000 2620 -3780 {lab=VDD}
N 2640 -3840 2640 -3620 {lab=VSS}
N 2590 -3820 2590 -3600 {lab=VSS}
N 2570 -3800 2570 -3580 {lab=VDD}
N 2620 -3780 2620 -3560 {lab=VDD}
N 2590 -3600 2590 -3380 {lab=VSS}
N 2640 -3620 2640 -3400 {lab=VSS}
N 2570 -3580 2570 -3360 {lab=VDD}
N 2620 -3560 2620 -3340 {lab=VDD}
N 2640 -3400 2640 -3180 {lab=VSS}
N 2590 -3380 2590 -3160 {lab=VSS}
N 2570 -3360 2570 -3140 {lab=VDD}
N 2620 -3340 2620 -3120 {lab=VDD}
N 2590 -3160 2590 -2940 {lab=VSS}
N 2640 -3180 2640 -2960 {lab=VSS}
N 2570 -3140 2570 -2920 {lab=VDD}
N 2620 -3120 2620 -2900 {lab=VDD}
N 2640 -2960 2640 -2740 {lab=VSS}
N 2590 -2940 2590 -2720 {lab=VSS}
N 2570 -2920 2570 -2700 {lab=VDD}
N 2620 -2900 2620 -2680 {lab=VDD}
N 2590 -2720 2590 -2500 {lab=VSS}
N 2640 -2740 2640 -2520 {lab=VSS}
N 2570 -2700 2570 -2480 {lab=VDD}
N 2620 -2680 2620 -2460 {lab=VDD}
N 2640 -2520 2640 -2300 {lab=VSS}
N 2590 -2500 2590 -2280 {lab=VSS}
N 2570 -2480 2570 -2260 {lab=VDD}
N 2620 -2460 2620 -2240 {lab=VDD}
N 2590 -2280 2590 -2060 {lab=VSS}
N 2640 -2300 2640 -2080 {lab=VSS}
N 2570 -2260 2570 -2040 {lab=VDD}
N 2620 -2240 2620 -2020 {lab=VDD}
N 2640 -2080 2640 -1860 {lab=VSS}
N 2590 -2060 2590 -1840 {lab=VSS}
N 2570 -2040 2570 -1820 {lab=VDD}
N 2620 -2020 2620 -1800 {lab=VDD}
N 2590 -1840 2590 -1620 {lab=VSS}
N 2640 -1860 2640 -1640 {lab=VSS}
N 2570 -1820 2570 -1600 {lab=VDD}
N 2620 -1800 2620 -1580 {lab=VDD}
N 2640 -1640 2640 -1420 {lab=VSS}
N 2590 -1620 2590 -1400 {lab=VSS}
N 2570 -1600 2570 -1380 {lab=VDD}
N 2620 -1580 2620 -1360 {lab=VDD}
N 2590 -1400 2590 -1180 {lab=VSS}
N 2640 -1420 2640 -1200 {lab=VSS}
N 2570 -1380 2570 -1160 {lab=VDD}
N 2620 -1360 2620 -1140 {lab=VDD}
N 2640 -1200 2640 -980 {lab=VSS}
N 2590 -1180 2590 -960 {lab=VSS}
N 2570 -7540 2570 -7320 {lab=VDD}
N 2620 -7520 2620 -7300 {lab=VDD}
N 2570 -7980 2570 -7760 {lab=VDD}
N 2620 -7960 2620 -7740 {lab=VDD}
N 2640 -7800 2640 -7580 {lab=VSS}
N 2590 -7780 2590 -7560 {lab=VSS}
N 2570 -11280 2570 -11060 {lab=VDD}
N 2620 -11260 2620 -11040 {lab=VDD}
N 2590 -11080 2590 -10860 {lab=VSS}
N 2640 -11100 2640 -10880 {lab=VSS}
N 2570 -11060 2570 -10840 {lab=VDD}
N 2620 -11040 2620 -10820 {lab=VDD}
N 2640 -10880 2640 -10660 {lab=VSS}
N 2590 -10860 2590 -10640 {lab=VSS}
N 2570 -11720 2570 -11500 {lab=VDD}
N 2620 -11700 2620 -11480 {lab=VDD}
N 2590 -11520 2590 -11300 {lab=VSS}
N 2640 -11540 2640 -11320 {lab=VSS}
N 2570 -11500 2570 -11280 {lab=VDD}
N 2620 -11480 2620 -11260 {lab=VDD}
N 2640 -11320 2640 -11100 {lab=VSS}
N 2590 -11300 2590 -11080 {lab=VSS}
N 2570 -12160 2570 -11940 {lab=VDD}
N 2620 -12140 2620 -11920 {lab=VDD}
N 2590 -11960 2590 -11740 {lab=VSS}
N 2640 -11980 2640 -11760 {lab=VSS}
N 2570 -11940 2570 -11720 {lab=VDD}
N 2620 -11920 2620 -11700 {lab=VDD}
N 2640 -11760 2640 -11540 {lab=VSS}
N 2590 -11740 2590 -11520 {lab=VSS}
N 2570 -12600 2570 -12380 {lab=VDD}
N 2620 -12580 2620 -12360 {lab=VDD}
N 2590 -12400 2590 -12180 {lab=VSS}
N 2640 -12420 2640 -12200 {lab=VSS}
N 2570 -12380 2570 -12160 {lab=VDD}
N 2620 -12360 2620 -12140 {lab=VDD}
N 2640 -12200 2640 -11980 {lab=VSS}
N 2590 -12180 2590 -11960 {lab=VSS}
N 2570 -13040 2570 -12820 {lab=VDD}
N 2620 -13020 2620 -12800 {lab=VDD}
N 2590 -12840 2590 -12620 {lab=VSS}
N 2640 -12860 2640 -12640 {lab=VSS}
N 2570 -12820 2570 -12600 {lab=VDD}
N 2620 -12800 2620 -12580 {lab=VDD}
N 2640 -12640 2640 -12420 {lab=VSS}
N 2590 -12620 2590 -12400 {lab=VSS}
N 2570 -13480 2570 -13260 {lab=VDD}
N 2620 -13460 2620 -13240 {lab=VDD}
N 2590 -13280 2590 -13060 {lab=VSS}
N 2640 -13300 2640 -13080 {lab=VSS}
N 2570 -13260 2570 -13040 {lab=VDD}
N 2620 -13240 2620 -13020 {lab=VDD}
N 2640 -13080 2640 -12860 {lab=VSS}
N 2590 -13060 2590 -12840 {lab=VSS}
N 2570 -13920 2570 -13700 {lab=VDD}
N 2620 -13900 2620 -13680 {lab=VDD}
N 2590 -13720 2590 -13500 {lab=VSS}
N 2640 -13740 2640 -13520 {lab=VSS}
N 2570 -13700 2570 -13480 {lab=VDD}
N 2620 -13680 2620 -13460 {lab=VDD}
N 2640 -13520 2640 -13300 {lab=VSS}
N 2590 -13500 2590 -13280 {lab=VSS}
N 2570 -14360 2570 -14140 {lab=VDD}
N 2620 -14340 2620 -14120 {lab=VDD}
N 2590 -14160 2590 -13940 {lab=VSS}
N 2640 -14180 2640 -13960 {lab=VSS}
N 2570 -14140 2570 -13920 {lab=VDD}
N 2620 -14120 2620 -13900 {lab=VDD}
N 2640 -13960 2640 -13740 {lab=VSS}
N 2590 -13940 2590 -13720 {lab=VSS}
N 2570 -14800 2570 -14580 {lab=VDD}
N 2620 -14780 2620 -14560 {lab=VDD}
N 2590 -14600 2590 -14380 {lab=VSS}
N 2640 -14620 2640 -14400 {lab=VSS}
N 2570 -14580 2570 -14360 {lab=VDD}
N 2620 -14560 2620 -14340 {lab=VDD}
N 2640 -14400 2640 -14180 {lab=VSS}
N 2590 -14380 2590 -14160 {lab=VSS}
N 2570 -15240 2570 -15020 {lab=VDD}
N 2620 -15220 2620 -15000 {lab=VDD}
N 2590 -15040 2590 -14820 {lab=VSS}
N 2640 -15060 2640 -14840 {lab=VSS}
N 2570 -15020 2570 -14800 {lab=VDD}
N 2620 -15000 2620 -14780 {lab=VDD}
N 2640 -14840 2640 -14620 {lab=VSS}
N 2590 -14820 2590 -14600 {lab=VSS}
N 2570 -15680 2570 -15460 {lab=VDD}
N 2620 -15660 2620 -15440 {lab=VDD}
N 2590 -15480 2590 -15260 {lab=VSS}
N 2640 -15500 2640 -15280 {lab=VSS}
N 2570 -15460 2570 -15240 {lab=VDD}
N 2620 -15440 2620 -15220 {lab=VDD}
N 2640 -15280 2640 -15060 {lab=VSS}
N 2590 -15260 2590 -15040 {lab=VSS}
N 2570 -16120 2570 -15900 {lab=VDD}
N 2620 -16100 2620 -15880 {lab=VDD}
N 2590 -15920 2590 -15700 {lab=VSS}
N 2640 -15940 2640 -15720 {lab=VSS}
N 2570 -15900 2570 -15680 {lab=VDD}
N 2620 -15880 2620 -15660 {lab=VDD}
N 2640 -15720 2640 -15500 {lab=VSS}
N 2590 -15700 2590 -15480 {lab=VSS}
N 2570 -16560 2570 -16340 {lab=VDD}
N 2620 -16540 2620 -16320 {lab=VDD}
N 2590 -16360 2590 -16140 {lab=VSS}
N 2640 -16380 2640 -16160 {lab=VSS}
N 2570 -16340 2570 -16120 {lab=VDD}
N 2620 -16320 2620 -16100 {lab=VDD}
N 2640 -16160 2640 -15940 {lab=VSS}
N 2590 -16140 2590 -15920 {lab=VSS}
N 2570 -17000 2570 -16780 {lab=VDD}
N 2620 -16980 2620 -16760 {lab=VDD}
N 2590 -16800 2590 -16580 {lab=VSS}
N 2640 -16820 2640 -16600 {lab=VSS}
N 2570 -16780 2570 -16560 {lab=VDD}
N 2620 -16760 2620 -16540 {lab=VDD}
N 2640 -16600 2640 -16380 {lab=VSS}
N 2590 -16580 2590 -16360 {lab=VSS}
N 2570 -17440 2570 -17220 {lab=VDD}
N 2620 -17420 2620 -17200 {lab=VDD}
N 2590 -17240 2590 -17020 {lab=VSS}
N 2640 -17260 2640 -17040 {lab=VSS}
N 2570 -17220 2570 -17000 {lab=VDD}
N 2620 -17200 2620 -16980 {lab=VDD}
N 2640 -17040 2640 -16820 {lab=VSS}
N 2590 -17020 2590 -16800 {lab=VSS}
N 2640 -17700 2640 -17480 {lab=VSS}
N 2570 -17660 2570 -17440 {lab=VDD}
N 2620 -17640 2620 -17420 {lab=VDD}
N 2640 -17480 2640 -17260 {lab=VSS}
N 2590 -17460 2590 -17240 {lab=VSS}
N 7420 -15900 7420 -15680 {lab=VDD}
N 7370 -15920 7370 -15700 {lab=VDD}
N 7420 -15460 7420 -15240 {lab=VDD}
N 7370 -15480 7370 -15260 {lab=VDD}
N 7400 -15660 7400 -15440 {lab=VSS}
N 7350 -15640 7350 -15420 {lab=VSS}
N 7420 -15680 7420 -15460 {lab=VDD}
N 7370 -15700 7370 -15480 {lab=VDD}
N 7350 -15860 7350 -15640 {lab=VSS}
N 7400 -15880 7400 -15660 {lab=VSS}
N 7420 -15020 7420 -14800 {lab=VDD}
N 7370 -15040 7370 -14820 {lab=VDD}
N 7400 -15220 7400 -15000 {lab=VSS}
N 7350 -15200 7350 -14980 {lab=VSS}
N 7420 -15240 7420 -15020 {lab=VDD}
N 7370 -15260 7370 -15040 {lab=VDD}
N 7350 -15420 7350 -15200 {lab=VSS}
N 7400 -15440 7400 -15220 {lab=VSS}
N 7420 -14580 7420 -14360 {lab=VDD}
N 7370 -14600 7370 -14380 {lab=VDD}
N 7400 -14780 7400 -14560 {lab=VSS}
N 7350 -14760 7350 -14540 {lab=VSS}
N 7420 -14800 7420 -14580 {lab=VDD}
N 7370 -14820 7370 -14600 {lab=VDD}
N 7350 -14980 7350 -14760 {lab=VSS}
N 7400 -15000 7400 -14780 {lab=VSS}
N 7420 -14140 7420 -13920 {lab=VDD}
N 7370 -14160 7370 -13940 {lab=VDD}
N 7400 -14340 7400 -14120 {lab=VSS}
N 7350 -14320 7350 -14100 {lab=VSS}
N 7420 -14360 7420 -14140 {lab=VDD}
N 7370 -14380 7370 -14160 {lab=VDD}
N 7350 -14540 7350 -14320 {lab=VSS}
N 7400 -14560 7400 -14340 {lab=VSS}
N 7420 -13700 7420 -13480 {lab=VDD}
N 7370 -13720 7370 -13500 {lab=VDD}
N 7400 -13900 7400 -13680 {lab=VSS}
N 7350 -13880 7350 -13660 {lab=VSS}
N 7420 -13920 7420 -13700 {lab=VDD}
N 7370 -13940 7370 -13720 {lab=VDD}
N 7350 -14100 7350 -13880 {lab=VSS}
N 7400 -14120 7400 -13900 {lab=VSS}
N 7420 -13260 7420 -13040 {lab=VDD}
N 7370 -13280 7370 -13060 {lab=VDD}
N 7400 -13460 7400 -13240 {lab=VSS}
N 7350 -13440 7350 -13220 {lab=VSS}
N 7420 -13480 7420 -13260 {lab=VDD}
N 7370 -13500 7370 -13280 {lab=VDD}
N 7350 -13660 7350 -13440 {lab=VSS}
N 7400 -13680 7400 -13460 {lab=VSS}
N 7420 -12820 7420 -12600 {lab=VDD}
N 7370 -12840 7370 -12620 {lab=VDD}
N 7400 -13020 7400 -12800 {lab=VSS}
N 7350 -13000 7350 -12780 {lab=VSS}
N 7420 -13040 7420 -12820 {lab=VDD}
N 7370 -13060 7370 -12840 {lab=VDD}
N 7350 -13220 7350 -13000 {lab=VSS}
N 7400 -13240 7400 -13020 {lab=VSS}
N 7420 -12380 7420 -12160 {lab=VDD}
N 7370 -12400 7370 -12180 {lab=VDD}
N 7400 -12580 7400 -12360 {lab=VSS}
N 7350 -12560 7350 -12340 {lab=VSS}
N 7420 -12600 7420 -12380 {lab=VDD}
N 7370 -12620 7370 -12400 {lab=VDD}
N 7350 -12780 7350 -12560 {lab=VSS}
N 7400 -12800 7400 -12580 {lab=VSS}
N 7420 -11940 7420 -11720 {lab=VDD}
N 7370 -11960 7370 -11740 {lab=VDD}
N 7400 -12140 7400 -11920 {lab=VSS}
N 7350 -12120 7350 -11900 {lab=VSS}
N 7420 -12160 7420 -11940 {lab=VDD}
N 7370 -12180 7370 -11960 {lab=VDD}
N 7350 -12340 7350 -12120 {lab=VSS}
N 7400 -12360 7400 -12140 {lab=VSS}
N 7420 -11500 7420 -11280 {lab=VDD}
N 7370 -11520 7370 -11300 {lab=VDD}
N 7400 -11700 7400 -11480 {lab=VSS}
N 7350 -11680 7350 -11460 {lab=VSS}
N 7420 -11720 7420 -11500 {lab=VDD}
N 7370 -11740 7370 -11520 {lab=VDD}
N 7350 -11900 7350 -11680 {lab=VSS}
N 7400 -11920 7400 -11700 {lab=VSS}
N 7420 -11060 7420 -10840 {lab=VDD}
N 7370 -11080 7370 -10860 {lab=VDD}
N 7400 -11260 7400 -11040 {lab=VSS}
N 7350 -11240 7350 -11020 {lab=VSS}
N 7420 -11280 7420 -11060 {lab=VDD}
N 7370 -11300 7370 -11080 {lab=VDD}
N 7350 -11460 7350 -11240 {lab=VSS}
N 7400 -11480 7400 -11260 {lab=VSS}
N 7420 -10620 7420 -10400 {lab=VDD}
N 7370 -10640 7370 -10420 {lab=VDD}
N 7400 -10820 7400 -10600 {lab=VSS}
N 7350 -10800 7350 -10580 {lab=VSS}
N 7420 -10840 7420 -10620 {lab=VDD}
N 7370 -10860 7370 -10640 {lab=VDD}
N 7350 -11020 7350 -10800 {lab=VSS}
N 7400 -11040 7400 -10820 {lab=VSS}
N 7420 -10180 7420 -9960 {lab=VDD}
N 7370 -10200 7370 -9980 {lab=VDD}
N 7400 -10380 7400 -10160 {lab=VSS}
N 7350 -10360 7350 -10140 {lab=VSS}
N 7420 -10400 7420 -10180 {lab=VDD}
N 7370 -10420 7370 -10200 {lab=VDD}
N 7350 -10580 7350 -10360 {lab=VSS}
N 7400 -10600 7400 -10380 {lab=VSS}
N 7420 -9740 7420 -9520 {lab=VDD}
N 7370 -9760 7370 -9540 {lab=VDD}
N 7400 -9940 7400 -9720 {lab=VSS}
N 7350 -9920 7350 -9700 {lab=VSS}
N 7420 -9960 7420 -9740 {lab=VDD}
N 7370 -9980 7370 -9760 {lab=VDD}
N 7350 -10140 7350 -9920 {lab=VSS}
N 7400 -10160 7400 -9940 {lab=VSS}
N 7420 -9300 7420 -9080 {lab=VDD}
N 7370 -9320 7370 -9100 {lab=VDD}
N 7400 -9500 7400 -9280 {lab=VSS}
N 7350 -9480 7350 -9260 {lab=VSS}
N 7420 -9520 7420 -9300 {lab=VDD}
N 7370 -9540 7370 -9320 {lab=VDD}
N 7350 -9700 7350 -9480 {lab=VSS}
N 7400 -9720 7400 -9500 {lab=VSS}
N 7420 -8860 7420 -8640 {lab=VDD}
N 7370 -8880 7370 -8660 {lab=VDD}
N 7400 -9060 7400 -8840 {lab=VSS}
N 7350 -9040 7350 -8820 {lab=VSS}
N 7420 -9080 7420 -8860 {lab=VDD}
N 7370 -9100 7370 -8880 {lab=VDD}
N 7350 -9260 7350 -9040 {lab=VSS}
N 7400 -9280 7400 -9060 {lab=VSS}
N 7420 -8420 7420 -8200 {lab=VDD}
N 7370 -8440 7370 -8220 {lab=VDD}
N 7400 -8620 7400 -8400 {lab=VSS}
N 7350 -8600 7350 -8380 {lab=VSS}
N 7420 -8640 7420 -8420 {lab=VDD}
N 7370 -8660 7370 -8440 {lab=VDD}
N 7350 -8820 7350 -8600 {lab=VSS}
N 7400 -8840 7400 -8620 {lab=VSS}
N 7420 -8200 7420 -7980 {lab=VDD}
N 7370 -8220 7370 -8000 {lab=VDD}
N 7350 -8380 7350 -8160 {lab=VSS}
N 7400 -8400 7400 -8180 {lab=VSS}
N 7420 -7540 7420 -7320 {lab=VDD}
N 7370 -7560 7370 -7340 {lab=VDD}
N 7400 -7740 7400 -7520 {lab=VSS}
N 7350 -7720 7350 -7500 {lab=VSS}
N 7640 -7350 7640 -7340 {lab=VDD}
N 7420 -7980 7420 -7760 {lab=VDD}
N 7370 -8000 7370 -7780 {lab=VDD}
N 7400 -8180 7400 -7960 {lab=VSS}
N 7350 -8160 7350 -7940 {lab=VSS}
N 7640 -7960 7640 -7940 {lab=VSS}
N 7420 -7760 7420 -7540 {lab=VDD}
N 7370 -7780 7370 -7560 {lab=VDD}
N 7350 -7940 7350 -7720 {lab=VSS}
N 7400 -7960 7400 -7740 {lab=VSS}
N 7350 -7500 7350 -7280 {lab=VSS}
N 2570 -8200 2570 -7980 {lab=VDD}
N 2620 -8180 2620 -7960 {lab=VDD}
N 2590 -8000 2590 -7780 {lab=VSS}
N 2640 -8020 2640 -7800 {lab=VSS}
N 2570 -7760 2570 -7540 {lab=VDD}
N 2620 -7740 2620 -7520 {lab=VDD}
N 2590 -7560 2590 -7340 {lab=VSS}
N 2640 -7580 2640 -7360 {lab=VSS}
N 2350 -7370 2350 -7360 {lab=VSS}
N 6260 -200 6480 -200 {lab=VDD}
N 6280 -250 6500 -250 {lab=VDD}
N 6460 -220 6680 -220 {lab=VSS}
N 6440 -270 6660 -270 {lab=VSS}
N 5820 -200 6040 -200 {lab=VDD}
N 5840 -250 6060 -250 {lab=VDD}
N 6000 -270 6220 -270 {lab=VSS}
N 6020 -220 6240 -220 {lab=VSS}
N 5600 -200 5820 -200 {lab=VDD}
N 5620 -250 5840 -250 {lab=VDD}
N 5800 -220 6020 -220 {lab=VSS}
N 5780 -270 6000 -270 {lab=VSS}
N 5280 -200 5600 -200 {lab=VDD}
N 5300 -250 5620 -250 {lab=VDD}
N 5580 -220 5800 -220 {lab=VSS}
N 5560 -270 5780 -270 {lab=VSS}
N 4400 -200 4620 -200 {lab=VDD}
N 4420 -250 4640 -250 {lab=VDD}
N 4600 -220 4820 -220 {lab=VSS}
N 4580 -270 4800 -270 {lab=VSS}
N 4180 -200 4400 -200 {lab=VDD}
N 4200 -250 4420 -250 {lab=VDD}
N 4380 -220 4600 -220 {lab=VSS}
N 4360 -270 4580 -270 {lab=VSS}
N 3960 -200 4180 -200 {lab=VDD}
N 3980 -250 4200 -250 {lab=VDD}
N 4140 -270 4360 -270 {lab=VSS}
N 4160 -220 4380 -220 {lab=VSS}
N 7370 -17720 7370 -17460 {lab=VDD}
N 7400 -17750 7400 -17640 {lab=VSS}
N 7350 -17700 7350 -17620 {lab=VSS}
N 7420 -17220 7420 -17000 {lab=VDD}
N 7370 -17240 7370 -17020 {lab=VDD}
N 7400 -17420 7400 -17200 {lab=VSS}
N 7350 -17400 7350 -17180 {lab=VSS}
N 7420 -17440 7420 -17220 {lab=VDD}
N 7370 -17460 7370 -17240 {lab=VDD}
N 7350 -17620 7350 -17400 {lab=VSS}
N 7400 -17640 7400 -17420 {lab=VSS}
N 7420 -16780 7420 -16560 {lab=VDD}
N 7370 -16800 7370 -16580 {lab=VDD}
N 7400 -16980 7400 -16760 {lab=VSS}
N 7350 -16960 7350 -16740 {lab=VSS}
N 7420 -17000 7420 -16780 {lab=VDD}
N 7370 -17020 7370 -16800 {lab=VDD}
N 7350 -17180 7350 -16960 {lab=VSS}
N 7400 -17200 7400 -16980 {lab=VSS}
N 7420 -16340 7420 -16120 {lab=VDD}
N 7370 -16360 7370 -16140 {lab=VDD}
N 7400 -16540 7400 -16320 {lab=VSS}
N 7350 -16520 7350 -16300 {lab=VSS}
N 7420 -16560 7420 -16340 {lab=VDD}
N 7370 -16580 7370 -16360 {lab=VDD}
N 7350 -16740 7350 -16520 {lab=VSS}
N 7400 -16760 7400 -16540 {lab=VSS}
N 7350 -16300 7350 -16080 {lab=VSS}
N 7400 -16320 7400 -16100 {lab=VSS}
N 7400 -7520 7400 -7300 {lab=VSS}
N 7370 -6020 7370 -5900 {lab=VDD}
N 7640 -9550 7640 -9520 {lab=VDD}
N 7420 -9520 7640 -9520 {lab=VDD}
N 7600 -9550 7600 -9540 {lab=VDD}
N 7370 -9540 7600 -9540 {lab=VDD}
N 7640 -9720 7640 -9690 {lab=VSS}
N 7400 -9720 7640 -9720 {lab=VSS}
N 7350 -9700 7600 -9700 {lab=VSS}
N 7600 -9700 7600 -9690 {lab=VSS}
N 7640 -9110 7640 -9080 {lab=VDD}
N 7420 -9080 7640 -9080 {lab=VDD}
N 7600 -9110 7600 -9100 {lab=VDD}
N 7370 -9100 7600 -9100 {lab=VDD}
N 7640 -9280 7640 -9250 {lab=VSS}
N 7400 -9280 7640 -9280 {lab=VSS}
N 7350 -9260 7600 -9260 {lab=VSS}
N 7600 -9260 7600 -9250 {lab=VSS}
N 7640 -9330 7640 -9300 {lab=VDD}
N 7420 -9300 7640 -9300 {lab=VDD}
N 7600 -9330 7600 -9320 {lab=VDD}
N 7370 -9320 7600 -9320 {lab=VDD}
N 7600 -9480 7600 -9470 {lab=VSS}
N 7350 -9480 7600 -9480 {lab=VSS}
N 7640 -9500 7640 -9470 {lab=VSS}
N 7400 -9500 7640 -9500 {lab=VSS}
N 7640 -8670 7640 -8640 {lab=VDD}
N 7420 -8640 7640 -8640 {lab=VDD}
N 7600 -8670 7600 -8660 {lab=VDD}
N 7370 -8660 7600 -8660 {lab=VDD}
N 7640 -8840 7640 -8810 {lab=VSS}
N 7400 -8840 7640 -8840 {lab=VSS}
N 7350 -8820 7600 -8820 {lab=VSS}
N 7600 -8820 7600 -8810 {lab=VSS}
N 7640 -8890 7640 -8860 {lab=VDD}
N 7420 -8860 7640 -8860 {lab=VDD}
N 7600 -8890 7600 -8880 {lab=VDD}
N 7370 -8880 7600 -8880 {lab=VDD}
N 7600 -9040 7600 -9030 {lab=VSS}
N 7350 -9040 7600 -9040 {lab=VSS}
N 7640 -9060 7640 -9030 {lab=VSS}
N 7400 -9060 7640 -9060 {lab=VSS}
N 7640 -8230 7640 -8200 {lab=VDD}
N 7420 -8200 7640 -8200 {lab=VDD}
N 7600 -8230 7600 -8220 {lab=VDD}
N 7370 -8220 7600 -8220 {lab=VDD}
N 7640 -8400 7640 -8370 {lab=VSS}
N 7400 -8400 7640 -8400 {lab=VSS}
N 7350 -8380 7600 -8380 {lab=VSS}
N 7600 -8380 7600 -8370 {lab=VSS}
N 7640 -8450 7640 -8420 {lab=VDD}
N 7420 -8420 7640 -8420 {lab=VDD}
N 7600 -8450 7600 -8440 {lab=VDD}
N 7370 -8440 7600 -8440 {lab=VDD}
N 7600 -8600 7600 -8590 {lab=VSS}
N 7350 -8600 7600 -8600 {lab=VSS}
N 7640 -8620 7640 -8590 {lab=VSS}
N 7400 -8620 7640 -8620 {lab=VSS}
N 7480 -8300 7840 -8300 {lab=ESD_DIODES_GUARD_PAD}
N 7300 -8300 7480 -8300 {lab=ESD_DIODES_GUARD_PAD}
N 7780 -8740 7840 -8740 {lab=ESD_DIODES_FOUNDRY_VDD_ANODE_PAD}
N 7300 -8720 7480 -8720 {lab=ESD_DIODES_GUARD_PAD}
N 7220 -8740 7470 -8740 {lab=ESD_DIODES_FOUNDRY_VDD_ANODE_PAD}
N 7470 -8740 7480 -8740 {lab=ESD_DIODES_FOUNDRY_VDD_ANODE_PAD}
N 7780 -9180 7840 -9180 {lab=ESD_DIODES_FOUNDRY_VSS_PAD}
N 7300 -9160 7480 -9160 {lab=ESD_DIODES_GUARD_PAD}
N 7220 -9180 7480 -9180 {lab=ESD_DIODES_FOUNDRY_VSS_PAD}
N 7780 -9620 7840 -9620 {lab=ESD_DIODES_FOUNDRY_VDD_CATHODE_PAD}
N 7300 -9600 7480 -9600 {lab=ESD_DIODES_GUARD_PAD}
N 7040 -8740 7220 -8740 {lab=ESD_DIODES_FOUNDRY_VDD_ANODE_PAD}
N 7040 -9080 7040 -8740 {lab=ESD_DIODES_FOUNDRY_VDD_ANODE_PAD}
N 7040 -9620 7040 -9140 {lab=ESD_DIODES_FOUNDRY_VDD_CATHODE_PAD}
N 7040 -9620 7480 -9620 {lab=ESD_DIODES_FOUNDRY_VDD_CATHODE_PAD}
N 7220 -9120 7350 -9120 {lab=VSS}
N 7300 -9880 7300 -8300 {lab=ESD_DIODES_GUARD_PAD}
N 2350 -8860 2350 -8830 {lab=VDD}
N 2350 -8860 2570 -8860 {lab=VDD}
N 2390 -8840 2390 -8830 {lab=VDD}
N 2390 -8840 2620 -8840 {lab=VDD}
N 2350 -8690 2350 -8660 {lab=VSS}
N 2350 -8660 2590 -8660 {lab=VSS}
N 2390 -8680 2640 -8680 {lab=VSS}
N 2390 -8690 2390 -8680 {lab=VSS}
N 2350 -9300 2350 -9270 {lab=VDD}
N 2350 -9300 2570 -9300 {lab=VDD}
N 2390 -9280 2390 -9270 {lab=VDD}
N 2390 -9280 2620 -9280 {lab=VDD}
N 2350 -9130 2350 -9100 {lab=VSS}
N 2350 -9100 2590 -9100 {lab=VSS}
N 2390 -9120 2640 -9120 {lab=VSS}
N 2390 -9130 2390 -9120 {lab=VSS}
N 2350 -9080 2350 -9050 {lab=VDD}
N 2350 -9080 2570 -9080 {lab=VDD}
N 2390 -9060 2390 -9050 {lab=VDD}
N 2390 -9060 2620 -9060 {lab=VDD}
N 2390 -8910 2390 -8900 {lab=VSS}
N 2390 -8900 2640 -8900 {lab=VSS}
N 2350 -8910 2350 -8880 {lab=VSS}
N 2350 -8880 2590 -8880 {lab=VSS}
N 2350 -9740 2350 -9710 {lab=VDD}
N 2350 -9740 2570 -9740 {lab=VDD}
N 2390 -9720 2390 -9710 {lab=VDD}
N 2390 -9720 2620 -9720 {lab=VDD}
N 2350 -9570 2350 -9540 {lab=VSS}
N 2350 -9540 2590 -9540 {lab=VSS}
N 2390 -9560 2640 -9560 {lab=VSS}
N 2390 -9570 2390 -9560 {lab=VSS}
N 2350 -9520 2350 -9490 {lab=VDD}
N 2350 -9520 2570 -9520 {lab=VDD}
N 2390 -9500 2390 -9490 {lab=VDD}
N 2390 -9500 2620 -9500 {lab=VDD}
N 2390 -9350 2390 -9340 {lab=VSS}
N 2390 -9340 2640 -9340 {lab=VSS}
N 2350 -9350 2350 -9320 {lab=VSS}
N 2350 -9320 2590 -9320 {lab=VSS}
N 2350 -10180 2350 -10150 {lab=VDD}
N 2350 -10180 2570 -10180 {lab=VDD}
N 2390 -10160 2390 -10150 {lab=VDD}
N 2390 -10160 2620 -10160 {lab=VDD}
N 2350 -10010 2350 -9980 {lab=VSS}
N 2350 -9980 2590 -9980 {lab=VSS}
N 2390 -10000 2640 -10000 {lab=VSS}
N 2390 -10010 2390 -10000 {lab=VSS}
N 2350 -9960 2350 -9930 {lab=VDD}
N 2350 -9960 2570 -9960 {lab=VDD}
N 2390 -9940 2390 -9930 {lab=VDD}
N 2390 -9940 2620 -9940 {lab=VDD}
N 2390 -9790 2390 -9780 {lab=VSS}
N 2390 -9780 2640 -9780 {lab=VSS}
N 2350 -9790 2350 -9760 {lab=VSS}
N 2350 -9760 2590 -9760 {lab=VSS}
N 2350 -10620 2350 -10590 {lab=VDD}
N 2350 -10620 2570 -10620 {lab=VDD}
N 2390 -10600 2390 -10590 {lab=VDD}
N 2390 -10600 2620 -10600 {lab=VDD}
N 2350 -10450 2350 -10420 {lab=VSS}
N 2350 -10420 2590 -10420 {lab=VSS}
N 2390 -10440 2640 -10440 {lab=VSS}
N 2390 -10450 2390 -10440 {lab=VSS}
N 2350 -10400 2350 -10370 {lab=VDD}
N 2350 -10400 2570 -10400 {lab=VDD}
N 2390 -10380 2390 -10370 {lab=VDD}
N 2390 -10380 2620 -10380 {lab=VDD}
N 2390 -10230 2390 -10220 {lab=VSS}
N 2390 -10220 2640 -10220 {lab=VSS}
N 2350 -10230 2350 -10200 {lab=VSS}
N 2350 -10200 2590 -10200 {lab=VSS}
N 2350 -8420 2350 -8390 {lab=VDD}
N 2350 -8420 2570 -8420 {lab=VDD}
N 2390 -8400 2390 -8390 {lab=VDD}
N 2390 -8400 2620 -8400 {lab=VDD}
N 2350 -8250 2350 -8220 {lab=VSS}
N 2390 -8240 2640 -8240 {lab=VSS}
N 2390 -8250 2390 -8240 {lab=VSS}
N 2350 -8640 2350 -8610 {lab=VDD}
N 2350 -8640 2570 -8640 {lab=VDD}
N 2390 -8620 2390 -8610 {lab=VDD}
N 2390 -8620 2620 -8620 {lab=VDD}
N 2390 -8470 2390 -8460 {lab=VSS}
N 2390 -8460 2640 -8460 {lab=VSS}
N 2350 -8470 2350 -8440 {lab=VSS}
N 2350 -8440 2590 -8440 {lab=VSS}
N 2570 -8420 2570 -8200 {lab=VDD}
N 2620 -8400 2620 -8180 {lab=VDD}
N 2150 -10520 2510 -10520 {lab=CAPACITORS_MIM_GUARD2_PAD}
N 2150 -9200 2210 -9200 {lab=CAPACITORS_MIM_2p0FF_8192FF_MAX_PERIM_1_PAD}
N 2150 -8760 2210 -8760 {lab=CAPACITORS_MIM_2p0FF_8192FF_MAX_PERIM_2_PAD}
N 2690 -9830 2690 -8380 {lab=CAPACITORS_MIM_GUARD1_PAD}
N 2510 -9200 2810 -9200 {lab=CAPACITORS_MIM_2p0FF_8192FF_MAX_PERIM_1_PAD}
N 2510 -9660 2690 -9660 {lab=CAPACITORS_MIM_GUARD1_PAD}
N 2510 -8760 2950 -8760 {lab=CAPACITORS_MIM_2p0FF_8192FF_MAX_PERIM_2_PAD}
N 2510 -8780 2690 -8780 {lab=CAPACITORS_MIM_GUARD1_PAD}
N 2150 -8320 2510 -8320 {lab=CAPACITORS_MIM_GUARD1_PAD}
N 2950 -9020 2950 -8760 {lab=CAPACITORS_MIM_2p0FF_8192FF_MAX_PERIM_2_PAD}
N 2810 -9200 2950 -9200 {lab=CAPACITORS_MIM_2p0FF_8192FF_MAX_PERIM_1_PAD}
N 2950 -9200 2950 -9080 {lab=CAPACITORS_MIM_2p0FF_8192FF_MAX_PERIM_1_PAD}
N 2510 -9640 2890 -9640 {lab=CAPACITORS_MIM_2p0FF_8192FF_2_PAD}
N 2150 -9640 2210 -9640 {lab=CAPACITORS_MIM_2p0FF_8192FF_2_PAD}
N 2510 -9660 2690 -9660 {lab=CAPACITORS_MIM_GUARD1_PAD}
N 2150 -10080 2210 -10080 {lab=CAPACITORS_MIM_2p0FF_8192FF_1_PAD}
N 2510 -10080 2910 -10080 {lab=CAPACITORS_MIM_2p0FF_8192FF_1_PAD}
N 2910 -10080 2910 -9940 {lab=CAPACITORS_MIM_2p0FF_8192FF_1_PAD}
N 2910 -9880 2910 -9640 {lab=CAPACITORS_MIM_2p0FF_8192FF_2_PAD}
N 2890 -9640 2910 -9640 {lab=CAPACITORS_MIM_2p0FF_8192FF_2_PAD}
N 2690 -8380 2690 -8320 {lab=CAPACITORS_MIM_GUARD1_PAD}
N 2510 -8320 2690 -8320 {lab=CAPACITORS_MIM_GUARD1_PAD}
N 2510 -10520 2710 -10520 {lab=CAPACITORS_MIM_GUARD2_PAD}
N 2710 -10520 2710 -8320 {lab=CAPACITORS_MIM_GUARD2_PAD}
N 2510 -9220 2710 -9220 {lab=CAPACITORS_MIM_GUARD2_PAD}
N 2510 -10100 2710 -10100 {lab=CAPACITORS_MIM_GUARD2_PAD}
N 2690 -10500 2690 -9830 {lab=CAPACITORS_MIM_GUARD1_PAD}
N 2570 -10840 2570 -8420 {lab=VDD}
N 2590 -10640 2590 -8000 {lab=VSS}
N 2620 -10820 2620 -8400 {lab=VDD}
N 2640 -10660 2640 -8020 {lab=VSS}
N 2350 -8220 2590 -8220 {lab=VSS}
N 7640 -9770 7640 -9740 {lab=VDD}
N 7420 -9740 7640 -9740 {lab=VDD}
N 7600 -9770 7600 -9760 {lab=VDD}
N 7370 -9760 7600 -9760 {lab=VDD}
N 7640 -9940 7640 -9910 {lab=VSS}
N 7400 -9940 7640 -9940 {lab=VSS}
N 7350 -9920 7600 -9920 {lab=VSS}
N 7600 -9920 7600 -9910 {lab=VSS}
N 7640 -17020 7640 -17000 {lab=VDD}
N 7420 -17000 7640 -17000 {lab=VDD}
N 7370 -17020 7640 -17020 {lab=VDD}
N 7640 -17200 7640 -17170 {lab=VSS}
N 7400 -17200 7640 -17200 {lab=VSS}
N 7350 -17180 7600 -17180 {lab=VSS}
N 7640 -17030 7840 -17030 {lab=VDD}
N 7840 -17100 7850 -17100 {lab=VDD}
N 7840 -17100 7840 -17030 {lab=VDD}
N 7600 -17180 7600 -17170 {lab=VSS}
N 7640 -17470 7640 -17440 {lab=VDD}
N 7420 -17440 7640 -17440 {lab=VDD}
N 7600 -17470 7600 -17460 {lab=VDD}
N 7370 -17460 7600 -17460 {lab=VDD}
N 7640 -17620 7640 -17610 {lab=VSS}
N 7350 -17620 7640 -17620 {lab=VSS}
N 7640 -17620 7840 -17620 {lab=VSS}
N 7840 -17620 7840 -17540 {lab=VSS}
N 7840 -17540 7850 -17540 {lab=VSS}
N 7640 -17250 7640 -17220 {lab=VDD}
N 7420 -17220 7640 -17220 {lab=VDD}
N 7600 -17250 7600 -17240 {lab=VDD}
N 7370 -17240 7600 -17240 {lab=VDD}
N 7600 -17400 7600 -17390 {lab=VSS}
N 7350 -17400 7600 -17400 {lab=VSS}
N 7640 -17420 7640 -17390 {lab=VSS}
N 7400 -17420 7640 -17420 {lab=VSS}
N 7420 -17220 7420 -17000 {lab=VDD}
N 7640 -17030 7640 -17020 {lab=VDD}
N 7640 -17640 7640 -17620 {lab=VSS}
N 7420 -17440 7420 -17220 {lab=VDD}
N 7350 -17990 7380 -17990 {lab=VDD}
N 7380 -17990 7380 -17770 {lab=VDD}
N 7350 -17950 7360 -17950 {lab=VDD}
N 7360 -17950 7360 -17720 {lab=VDD}
N 7180 -17990 7210 -17990 {lab=VSS}
N 7180 -17990 7180 -17750 {lab=VSS}
N 7200 -17950 7200 -17700 {lab=VSS}
N 7200 -17950 7210 -17950 {lab=VSS}
N 7130 -17990 7160 -17990 {lab=VDD}
N 7160 -17990 7160 -17770 {lab=VDD}
N 7130 -17950 7140 -17950 {lab=VDD}
N 7140 -17950 7140 -17720 {lab=VDD}
N 6960 -17990 6990 -17990 {lab=VSS}
N 6960 -17990 6960 -17750 {lab=VSS}
N 6980 -17950 6980 -17700 {lab=VSS}
N 6980 -17950 6990 -17950 {lab=VSS}
N 5810 -17990 5840 -17990 {lab=VDD}
N 5840 -17990 5840 -17770 {lab=VDD}
N 5810 -17950 5820 -17950 {lab=VDD}
N 5820 -17950 5820 -17720 {lab=VDD}
N 5640 -17990 5670 -17990 {lab=VSS}
N 5640 -17990 5640 -17750 {lab=VSS}
N 5660 -17950 5660 -17700 {lab=VSS}
N 5660 -17950 5670 -17950 {lab=VSS}
N 5740 -18190 5740 -17830 {lab=PAD_ESD_ASIG_GUARD_OUT_PAD}
N 6500 -17990 6500 -17770 {lab=VDD}
N 6470 -17950 6480 -17950 {lab=VDD}
N 6470 -17990 6500 -17990 {lab=VDD}
N 6480 -17950 6480 -17720 {lab=VDD}
N 6300 -17990 6330 -17990 {lab=VSS}
N 6300 -17990 6300 -17750 {lab=VSS}
N 6320 -17950 6320 -17700 {lab=VSS}
N 6320 -17950 6330 -17950 {lab=VSS}
N 6400 -18190 6400 -18130 {lab=PAD_ESD_ASIG_GUARD_IN_PAD}
N 6720 -17990 6720 -17770 {lab=VDD}
N 6690 -17950 6700 -17950 {lab=VDD}
N 6690 -17990 6720 -17990 {lab=VDD}
N 6700 -17950 6700 -17720 {lab=VDD}
N 6520 -17990 6550 -17990 {lab=VSS}
N 6520 -17990 6520 -17750 {lab=VSS}
N 6540 -17950 6550 -17950 {lab=VSS}
N 6540 -17950 6540 -17700 {lab=VSS}
N 6940 -17990 6940 -17770 {lab=VDD}
N 6910 -17950 6920 -17950 {lab=VDD}
N 6910 -17990 6940 -17990 {lab=VDD}
N 6920 -17950 6920 -17720 {lab=VDD}
N 6760 -17950 6770 -17950 {lab=VSS}
N 6760 -17950 6760 -17700 {lab=VSS}
N 6740 -17990 6770 -17990 {lab=VSS}
N 6740 -17990 6740 -17750 {lab=VSS}
N 6160 -17640 7060 -17640 {lab=PAD_ESD_TEST_GUARD_PAD}
N 6450 -17720 6450 -17530 {lab=VDD}
N 6350 -17700 6350 -17530 {lab=VSS}
N 6400 -17470 6400 -17420 {lab=PAD_ESD_ASIG_GUARD_OUT_PAD}
N 5960 -17420 6400 -17420 {lab=PAD_ESD_ASIG_GUARD_OUT_PAD}
N 5420 -17640 6160 -17640 {lab=PAD_ESD_TEST_GUARD_PAD}
N 6380 -17650 6380 -17640 {lab=PAD_ESD_TEST_GUARD_PAD}
N 6060 -17990 6060 -17770 {lab=VDD}
N 6030 -17950 6040 -17950 {lab=VDD}
N 6030 -17990 6060 -17990 {lab=VDD}
N 6040 -17950 6040 -17720 {lab=VDD}
N 5860 -17990 5890 -17990 {lab=VSS}
N 5860 -17990 5860 -17750 {lab=VSS}
N 5880 -17950 5890 -17950 {lab=VSS}
N 5880 -17950 5880 -17700 {lab=VSS}
N 6280 -17990 6280 -17770 {lab=VDD}
N 6250 -17950 6260 -17950 {lab=VDD}
N 6250 -17990 6280 -17990 {lab=VDD}
N 6260 -17950 6260 -17720 {lab=VDD}
N 6100 -17950 6110 -17950 {lab=VSS}
N 6100 -17950 6100 -17700 {lab=VSS}
N 6080 -17990 6110 -17990 {lab=VSS}
N 6080 -17990 6080 -17750 {lab=VSS}
N 5740 -17420 5960 -17420 {lab=PAD_ESD_ASIG_GUARD_OUT_PAD}
N 4870 -17640 5420 -17640 {lab=PAD_ESD_TEST_GUARD_PAD}
N 7640 -17660 7640 -17640 {lab=VSS}
N 7420 -17770 7420 -17440 {lab=VDD}
N 7400 -17660 7640 -17660 {lab=VSS}
N 5680 -17770 5960 -17770 {lab=VDD}
N 5740 -17830 5740 -17420 {lab=PAD_ESD_ASIG_GUARD_OUT_PAD}
N 6380 -17830 6380 -17650 {lab=PAD_ESD_TEST_GUARD_PAD}
N 7020 -17770 7280 -17770 {lab=VDD}
N 6400 -17830 6400 -17570 {lab=#net4}
N 6180 -17770 6620 -17770 {lab=VDD}
N 2350 -17680 2350 -17660 {lab=VDD}
N 2350 -17680 2570 -17680 {lab=VDD}
N 2350 -17660 2620 -17660 {lab=VDD}
N 2350 -17510 2350 -17480 {lab=VSS}
N 2350 -17480 2590 -17480 {lab=VSS}
N 2390 -17500 2640 -17500 {lab=VSS}
N 2150 -17650 2350 -17650 {lab=VDD}
N 2140 -17580 2150 -17580 {lab=VDD}
N 2150 -17650 2150 -17580 {lab=VDD}
N 2390 -17510 2390 -17500 {lab=VSS}
N 2350 -17240 2350 -17210 {lab=VDD}
N 2350 -17240 2570 -17240 {lab=VDD}
N 2390 -17220 2390 -17210 {lab=VDD}
N 2390 -17220 2620 -17220 {lab=VDD}
N 2350 -17070 2350 -17060 {lab=VSS}
N 2350 -17060 2640 -17060 {lab=VSS}
N 2150 -17060 2350 -17060 {lab=VSS}
N 2150 -17140 2150 -17060 {lab=VSS}
N 2140 -17140 2150 -17140 {lab=VSS}
N 2350 -17460 2350 -17430 {lab=VDD}
N 2350 -17460 2570 -17460 {lab=VDD}
N 2390 -17440 2390 -17430 {lab=VDD}
N 2390 -17440 2620 -17440 {lab=VDD}
N 2390 -17290 2390 -17280 {lab=VSS}
N 2390 -17280 2640 -17280 {lab=VSS}
N 2350 -17290 2350 -17260 {lab=VSS}
N 2350 -17260 2590 -17260 {lab=VSS}
N 2350 -17660 2350 -17650 {lab=VDD}
N 2350 -17060 2350 -17040 {lab=VSS}
N 2350 -17040 2350 -17020 {lab=VSS}
N 2350 -17020 2590 -17020 {lab=VSS}
N 3950 -17990 3980 -17990 {lab=VDD}
N 3980 -17990 3980 -17770 {lab=VDD}
N 3950 -17950 3960 -17950 {lab=VDD}
N 3960 -17950 3960 -17720 {lab=VDD}
N 3780 -17990 3810 -17990 {lab=VSS}
N 3780 -17990 3780 -17750 {lab=VSS}
N 3800 -17950 3800 -17700 {lab=VSS}
N 3800 -17950 3810 -17950 {lab=VSS}
N 3730 -17990 3760 -17990 {lab=VDD}
N 3760 -17990 3760 -17770 {lab=VDD}
N 3730 -17950 3740 -17950 {lab=VDD}
N 3740 -17950 3740 -17720 {lab=VDD}
N 3580 -17950 3590 -17950 {lab=VSS}
N 3580 -17950 3580 -17700 {lab=VSS}
N 3560 -17990 3590 -17990 {lab=VSS}
N 3560 -17990 3560 -17750 {lab=VSS}
N 3880 -18190 3880 -17830 {lab=PAD_ESD_GUARDSENSE_SENSE_OUT_PAD}
N 3510 -17990 3540 -17990 {lab=VDD}
N 3540 -17990 3540 -17770 {lab=VDD}
N 3510 -17950 3520 -17950 {lab=VDD}
N 3520 -17950 3520 -17720 {lab=VDD}
N 3340 -17990 3370 -17990 {lab=VSS}
N 3340 -17990 3340 -17750 {lab=VSS}
N 3360 -17950 3360 -17700 {lab=VSS}
N 3360 -17950 3370 -17950 {lab=VSS}
N 3440 -18190 3440 -17830 {lab=PAD_ESD_GUARDSENSE_ASIG_OUT_PAD}
N 2850 -17990 2880 -17990 {lab=VDD}
N 2880 -17990 2880 -17770 {lab=VDD}
N 2850 -17950 2860 -17950 {lab=VDD}
N 2860 -17950 2860 -17720 {lab=VDD}
N 2700 -17950 2710 -17950 {lab=VSS}
N 2700 -17950 2700 -17700 {lab=VSS}
N 2680 -17990 2710 -17990 {lab=VSS}
N 2680 -17990 2680 -17750 {lab=VSS}
N 4960 -17990 4960 -17770 {lab=VDD}
N 4930 -17950 4940 -17950 {lab=VDD}
N 4930 -17990 4960 -17990 {lab=VDD}
N 4940 -17950 4940 -17720 {lab=VDD}
N 4660 -17990 4690 -17990 {lab=VSS}
N 4660 -17990 4660 -17750 {lab=VSS}
N 4680 -17950 4680 -17700 {lab=VSS}
N 4680 -17950 4690 -17950 {lab=VSS}
N 4860 -18190 4860 -18130 {lab=PAD_ESD_GUARDSENSE_ASIG_IN_PAD}
N 4760 -18190 4760 -18130 {lab=PAD_ESD_GUARDSENSE_SENSE_IN_PAD}
N 4810 -17830 4810 -17650 {lab=PAD_RES_DEBUG}
N 4870 -17830 4870 -17640 {lab=PAD_ESD_TEST_GUARD_PAD}
N 4960 -17540 4960 -17280 {lab=PAD_RES_DEBUG}
N 5010 -17430 5010 -17240 {lab=VDD}
N 4910 -17410 4910 -17240 {lab=VSS}
N 4810 -17650 4810 -17540 {lab=PAD_RES_DEBUG}
N 4810 -17540 4960 -17540 {lab=PAD_RES_DEBUG}
N 5010 -17720 5010 -17430 {lab=VDD}
N 4910 -17700 4910 -17410 {lab=VSS}
N 4200 -17990 4200 -17770 {lab=VDD}
N 4170 -17950 4180 -17950 {lab=VDD}
N 4170 -17990 4200 -17990 {lab=VDD}
N 4180 -17950 4180 -17720 {lab=VDD}
N 4020 -17950 4030 -17950 {lab=VSS}
N 4020 -17950 4020 -17700 {lab=VSS}
N 4000 -17990 4030 -17990 {lab=VSS}
N 4000 -17990 4000 -17750 {lab=VSS}
N 4640 -17990 4640 -17770 {lab=VDD}
N 4610 -17950 4620 -17950 {lab=VDD}
N 4610 -17990 4640 -17990 {lab=VDD}
N 4620 -17950 4620 -17720 {lab=VDD}
N 4440 -17990 4470 -17990 {lab=VSS}
N 4440 -17990 4440 -17750 {lab=VSS}
N 4460 -17950 4470 -17950 {lab=VSS}
N 4460 -17950 4460 -17700 {lab=VSS}
N 3870 -17830 3880 -17830 {lab=PAD_ESD_GUARDSENSE_SENSE_OUT_PAD}
N 4760 -17830 4760 -17560 {lab=SENSE_RES_DEBUG}
N 5180 -17990 5180 -17770 {lab=VDD}
N 5150 -17950 5160 -17950 {lab=VDD}
N 5150 -17990 5180 -17990 {lab=VDD}
N 5160 -17950 5160 -17720 {lab=VDD}
N 5000 -17950 5010 -17950 {lab=VSS}
N 5000 -17950 5000 -17700 {lab=VSS}
N 4980 -17990 5010 -17990 {lab=VSS}
N 4980 -17990 4980 -17750 {lab=VSS}
N 5620 -17990 5620 -17770 {lab=VDD}
N 5590 -17950 5600 -17950 {lab=VDD}
N 5590 -17990 5620 -17990 {lab=VDD}
N 5600 -17950 5600 -17720 {lab=VDD}
N 5420 -17990 5450 -17990 {lab=VSS}
N 5420 -17990 5420 -17750 {lab=VSS}
N 5440 -17950 5450 -17950 {lab=VSS}
N 5440 -17950 5440 -17700 {lab=VSS}
N 4670 -17560 4760 -17560 {lab=SENSE_RES_DEBUG}
N 4670 -17560 4670 -17470 {lab=SENSE_RES_DEBUG}
N 4670 -17470 4670 -17460 {lab=SENSE_RES_DEBUG}
N 4720 -17720 4720 -17420 {lab=VDD}
N 4620 -17700 4620 -17420 {lab=VSS}
N 3440 -17830 3450 -17830 {lab=PAD_ESD_GUARDSENSE_ASIG_OUT_PAD}
N 4670 -17360 4670 -17310 {lab=PAD_ESD_GUARDSENSE_ASIG_OUT_PAD}
N 4950 -17180 4960 -17180 {lab=PAD_ESD_GUARDSENSE_SENSE_OUT_PAD}
N 3450 -17830 3450 -17310 {lab=PAD_ESD_GUARDSENSE_ASIG_OUT_PAD}
N 3880 -17830 3880 -17190 {lab=PAD_ESD_GUARDSENSE_SENSE_OUT_PAD}
N 3880 -17190 3880 -17180 {lab=PAD_ESD_GUARDSENSE_SENSE_OUT_PAD}
N 3450 -17310 4670 -17310 {lab=PAD_ESD_GUARDSENSE_ASIG_OUT_PAD}
N 3880 -17180 4950 -17180 {lab=PAD_ESD_GUARDSENSE_SENSE_OUT_PAD}
N 7050 -17830 7060 -17830 {lab=PAD_ESD_TEST_GUARD_PAD}
N 7050 -18190 7050 -17830 {lab=PAD_ESD_TEST_GUARD_PAD}
N 7050 -18190 7060 -18190 {lab=PAD_ESD_TEST_GUARD_PAD}
N 7050 -17830 7050 -17640 {lab=PAD_ESD_TEST_GUARD_PAD}
N 2150 -16240 2210 -16240 {lab=GUARD_IMPORTANCE_INPUT_PAD}
N 2510 -16680 2680 -16680 {lab=GUARD_IMPORTANCE_PAD_GUARD_PAD}
N 2680 -16680 2680 -16260 {lab=GUARD_IMPORTANCE_PAD_GUARD_PAD}
N 2510 -16260 2680 -16260 {lab=GUARD_IMPORTANCE_PAD_GUARD_PAD}
N 2510 -16240 3680 -16240 {lab=GUARD_IMPORTANCE_INPUT_PAD}
N 2510 -15800 2730 -15800 {lab=GUARD_IMPORTANCE_SIDE_GUARD_PAD}
N 2730 -16260 2730 -15800 {lab=GUARD_IMPORTANCE_SIDE_GUARD_PAD}
N 2730 -16260 3680 -16260 {lab=GUARD_IMPORTANCE_SIDE_GUARD_PAD}
N 2510 -15360 2780 -15360 {lab=GUARD_IMPORTANCE_BOTTOM_GUARD_PAD}
N 2780 -16220 2780 -15360 {lab=GUARD_IMPORTANCE_BOTTOM_GUARD_PAD}
N 2780 -16220 3680 -16220 {lab=GUARD_IMPORTANCE_BOTTOM_GUARD_PAD}
N 2140 -14920 2150 -14920 {lab=GUARD_IMPORTANCE_TOP_GUARD_PAD}
N 2510 -14920 2880 -14920 {lab=GUARD_IMPORTANCE_TOP_GUARD_PAD}
N 2880 -16200 2880 -14920 {lab=GUARD_IMPORTANCE_TOP_GUARD_PAD}
N 2880 -16200 3680 -16200 {lab=GUARD_IMPORTANCE_TOP_GUARD_PAD}
C {iopin.sym} 7850 -1700 0 0 {name=p3 lab=lv_nfet_W075L070_source_PAD}
C {iopin.sym} 7850 -2140 0 0 {name=p4 lab=lv_nfet_W075L070_gate_PAD}
C {iopin.sym} 7850 -2580 0 0 {name=p5 lab=lv_nfet_W075L070_drain_PAD}
C {iopin.sym} 7850 -3020 0 0 {name=p6 lab=lv_pfet_W075L070_source_PAD}
C {iopin.sym} 7850 -3460 0 0 {name=p7 lab=lv_pfet_W075L070_gate_PAD}
C {iopin.sym} 7850 -3900 0 0 {name=p8 lab=lv_pfet_W075L070_drain_PAD}
C {iopin.sym} 7850 -4340 0 0 {name=p9 lab=hv_nfet_W075L070_source_PAD}
C {iopin.sym} 7850 -4780 0 0 {name=p10 lab=hv_nfet_W075L070_gate_PAD}
C {iopin.sym} 7850 -5220 0 0 {name=p11 lab=hv_nfet_W075L070_drain_PAD}
C {iopin.sym} 7850 -5660 0 0 {name=p12 lab=hv_pfet_W075L070_source_PAD}
C {iopin.sym} 7850 -6100 0 0 {name=p13 lab=hv_pfet_W075L070_gate_PAD}
C {iopin.sym} 7850 -6540 0 0 {name=p14 lab=hv_pfet_W075L070_drain_PAD}
C {corner.sym} 3400 0 3 0 {name=x38}
C {gf180mcu_fd_io__dvss_70x100.sym} 7630 -820 2 0 {name=x40}
C {iopin.sym} 5380 220 1 0 {name=p21 lab=GUARDSENSE_ASIG_PAD}
C {iopin.sym} 5480 220 1 0 {name=p22 lab=GUARDSENSE_SENSE_PAD}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 3840 10 3 0 {name=x5[0..2]}
C {iopin.sym} 3620 220 1 0 {name=p1 lab=PAD_GUARD_PAD}
C {iopin.sym} 4060 220 1 0 {name=p2 lab=ASIG_FOUNDRY_PAD}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 4940 10 3 0 {name=x8[0..8]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill5.sym} 5160 10 3 0 {name=x4}
C {iopin.sym} 7020 220 1 0 {name=p16 lab=PAD_GUARD_PAD}
C {gf180mcu_liplib__no_esd_guarded_pad_70x100.sym} 6360 0 3 0 {name=x35}
C {iopin.sym} 6360 220 1 0 {name=p23 lab=EMPTY_PAD}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 6800 10 3 0 {name=x11[0..1]}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 3620 10 3 0 {name=x37}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 4060 10 3 0 {name=x2}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 7020 10 3 0 {name=x43}
C {gf180mcu_fd_io__dvss_70x100.sym} 2360 -380 0 0 {name=x45}
C {gf180mcu_fd_io__dvdd_70x100.sym} 7630 -380 2 0 {name=x5}
C {noconn.sym} 5370 -400 0 0 {name=l2}
C {noconn.sym} 5480 -400 0 0 {name=l3}
C {noconn.sym} 6360 -400 0 0 {name=l4}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 7630 -600 2 0 {name=x12[0..2]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 2360 -600 0 0 {name=x13[0..2]}
C {gf180mcu_fd_io__dvdd_70x100.sym} 2360 -820 0 0 {name=x39}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 7630 -6980 2 0 {name=x34}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 7630 -1040 2 0 {name=x14[0..2]}
C {iopin.sym} 7850 -1260 0 0 {name=p26 lab=guard_transistors_PAD}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 7630 -1260 2 0 {name=x41}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 7630 -1920 2 0 {name=x16[0..1]}
C {devices/code_shown.sym} 7490 -60 0 0 {name=NGSPICE only_toplevel=true
value="
* INCLUDING NOW
.include $::GF180MCU_FD_IO_PAD_70x100_SPICE
.include $::GF180MCU_FD_IO_SPICE
"}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 2360 -7000 0 0 {name=x30}
C {iopin.sym} 2150 -7000 2 0 {name=p36 lab=TOFILL23_PAD}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 2360 -6560 0 0 {name=x32}
C {iopin.sym} 2150 -6560 2 0 {name=p37 lab=TOFILL24_PAD}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 2360 -6120 0 0 {name=x42}
C {iopin.sym} 2150 -6120 2 0 {name=p38 lab=TOFILL25_PAD}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 2360 -5680 0 0 {name=x46}
C {iopin.sym} 2150 -5680 2 0 {name=p39 lab=TOFILL26_PAD}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 2360 -5240 0 0 {name=x47}
C {iopin.sym} 2150 -5240 2 0 {name=p40 lab=TOFILL27_PAD}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 2360 -4800 0 0 {name=x48}
C {iopin.sym} 2150 -4800 2 0 {name=p41 lab=TOFILL28_PAD}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 2360 -4360 0 0 {name=x49}
C {iopin.sym} 2150 -4360 2 0 {name=p42 lab=TOFILL29_PAD}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 2360 -3920 0 0 {name=x53}
C {iopin.sym} 2150 -3920 2 0 {name=p43 lab=TOFILL30_PAD}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 2360 -3480 0 0 {name=x54}
C {iopin.sym} 2150 -3480 2 0 {name=p44 lab=TOFILL31_PAD}
C {iopin.sym} 2150 -3040 2 0 {name=p45 lab=CHARGE_PUMP_VW_PAD}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 2360 -2600 0 0 {name=x56}
C {iopin.sym} 2150 -2600 2 0 {name=p46 lab=CHARGE_PUMP_G1_PAD}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 2360 -1720 0 0 {name=x58}
C {iopin.sym} 2150 -1720 2 0 {name=p48 lab=CHARGE_PUMP_G2_PAD}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 2360 -1280 0 0 {name=x59}
C {iopin.sym} 2150 -1280 2 0 {name=p49 lab=CHARGE_PUMP_GUARD_PAD}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 2360 -10960 0 0 {name=x76}
C {iopin.sym} 2150 -10960 2 0 {name=p54 lab=TOFILL16_PAD}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 2360 -11400 0 0 {name=x77}
C {iopin.sym} 2150 -11400 2 0 {name=p55 lab=TOFILL15_PAD}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 2360 -11840 0 0 {name=x78}
C {iopin.sym} 2150 -11840 2 0 {name=p56 lab=TOFILL14_PAD}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 2360 -12280 0 0 {name=x79}
C {iopin.sym} 2150 -12280 2 0 {name=p57 lab=TOFILL13_PAD}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 2360 -12720 0 0 {name=x89}
C {iopin.sym} 2150 -12720 2 0 {name=p58 lab=TOFILL12_PAD}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 2360 -13160 0 0 {name=x92}
C {iopin.sym} 2150 -13160 2 0 {name=p59 lab=TOFILL11_PAD}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 2360 -13600 0 0 {name=x93}
C {iopin.sym} 2150 -13600 2 0 {name=p60 lab=TOFILL10_PAD}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 2360 -14040 0 0 {name=x94}
C {iopin.sym} 2150 -14040 2 0 {name=p61 lab=TOFILL9_PAD}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 2360 -14480 0 0 {name=x95}
C {iopin.sym} 2150 -14480 2 0 {name=p62 lab=TOFILL8_PAD}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 2360 -14920 0 0 {name=x96}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 2360 -15360 0 0 {name=x97}
C {iopin.sym} 2150 -15360 2 0 {name=p64 lab=GUARD_IMPORTANCE_BOTTOM_GUARD_PAD

}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 2360 -15800 0 0 {name=x98}
C {iopin.sym} 2150 -15800 2 0 {name=p65 lab=GUARD_IMPORTANCE_SIDE_GUARD_PAD}
C {iopin.sym} 2150 -16240 2 0 {name=p66 lab=GUARD_IMPORTANCE_INPUT_PAD}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 2360 -16680 0 0 {name=x102}
C {iopin.sym} 2150 -16680 2 0 {name=p67 lab=GUARD_IMPORTANCE_PAD_GUARD_PAD}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 7630 -15780 2 0 {name=x106}
C {iopin.sym} 7840 -15780 0 0 {name=p70 lab=TOFILL49_PAD}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 7630 -15340 2 0 {name=x107}
C {iopin.sym} 7840 -15340 0 0 {name=p71 lab=TOFILL48_PAD}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 7630 -14900 2 0 {name=x108}
C {iopin.sym} 7840 -14900 0 0 {name=p72 lab=TOFILL47_PAD}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 7630 -14460 2 0 {name=x109}
C {iopin.sym} 7840 -14460 0 0 {name=p73 lab=TOFILL46_PAD}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 7630 -14020 2 0 {name=x113}
C {iopin.sym} 7840 -14020 0 0 {name=p74 lab=TOFILL45_PAD}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 7630 -13580 2 0 {name=x114}
C {iopin.sym} 7840 -13580 0 0 {name=p75 lab=TOFILL44_PAD}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 7630 -13140 2 0 {name=x115}
C {iopin.sym} 7840 -13140 0 0 {name=p76 lab=TOFILL43_PAD}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 7630 -12700 2 0 {name=x116}
C {iopin.sym} 7840 -12700 0 0 {name=p77 lab=TOFILL42_PAD}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 7630 -12260 2 0 {name=x117}
C {iopin.sym} 7840 -12260 0 0 {name=p78 lab=TOFILL41_PAD}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 7630 -11820 2 0 {name=x118}
C {iopin.sym} 7840 -11820 0 0 {name=p79 lab=TOFILL40_PAD}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 7630 -11380 2 0 {name=x119}
C {iopin.sym} 7840 -11380 0 0 {name=p80 lab=TOFILL39_PAD}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 7630 -10940 2 0 {name=x123}
C {iopin.sym} 7840 -10940 0 0 {name=p81 lab=TOFILL38_PAD}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 7630 -10500 2 0 {name=x124}
C {iopin.sym} 7840 -10500 0 0 {name=p82 lab=TOFILL37_PAD}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 7630 -10060 2 0 {name=x125}
C {iopin.sym} 7840 -10060 0 0 {name=p83 lab=TOFILL36_PAD}
C {gf180mcu_fd_io__dvss_70x100.sym} 7630 -7860 2 0 {name=x135}
C {gf180mcu_fd_io__dvdd_70x100.sym} 7630 -7420 2 0 {name=x136}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 7630 -7640 2 0 {name=x91[0..2]}
C {matched_interface_trap_charge_pumps.sym} 2950 -2160 0 0 {name=x133}
C {iopin.sym} 2140 -2160 2 0 {name=p47 lab=CHARGE_PUMP_VS_PAD}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 7630 -7200 2 0 {name=x37[0..2]}
C {gf180mcu_fd_io__dvdd_70x100.sym} 2360 -7880 0 0 {name=x55}
C {gf180mcu_fd_io__dvss_70x100.sym} 2360 -7440 0 0 {name=x137}
C {gf180mcu_liplib__asig_guard_sense_5p0_pad_70x100_p105.sym} 5430 0 3 0 {name=x44}
C {corner.sym} 7240 0 3 0 {name=x36}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill5.sym} 6580 10 3 0 {name=x72}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 6140 10 3 0 {name=x112}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill5.sym} 5920 10 3 0 {name=x73}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill1.sym} 5700 10 3 0 {name=x90[0..1]}
C {iopin.sym} 4720 220 1 0 {name=p50 lab=ASIG_GUARD_PAD}
C {gf180mcu_liplib__asig_guard_5p0_pad_70x100.sym} 4720 10 3 0 {name=x90}
C {noconn.sym} 4720 -400 0 0 {name=l5}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill1.sym} 4500 10 3 0 {name=x10[0..1]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 4280 10 3 0 {name=x92[0..9]}
C {gf180mcu_liplib__no_esd_guarded_pad_70x100.sym} 2370 -2160 0 0 {name=x3}
C {gf180mcu_liplib__no_esd_guarded_pad_70x100.sym} 2370 -3040 0 0 {name=x57}
C {fill_25.sym} 2370 -1940 0 0 {name=x60}
C {fill_25.sym} 2370 -2380 0 0 {name=x61}
C {fill_25.sym} 2370 -2820 0 0 {name=x62}
C {fill_25.sym} 2370 -3260 0 0 {name=x63}
C {gf180mcu_liplib__no_esd_guarded_pad_70x100.sym} 7620 -1700 2 0 {name=x64}
C {gf180mcu_liplib__no_esd_guarded_pad_70x100.sym} 7620 -2140 2 0 {name=x1}
C {gf180mcu_liplib__no_esd_guarded_pad_70x100.sym} 7620 -2580 2 0 {name=x6}
C {gf180mcu_liplib__no_esd_guarded_pad_70x100.sym} 7620 -3020 2 0 {name=x9}
C {gf180mcu_liplib__no_esd_guarded_pad_70x100.sym} 7620 -3460 2 0 {name=x11}
C {gf180mcu_liplib__no_esd_guarded_pad_70x100.sym} 7620 -3900 2 0 {name=x13}
C {gf180mcu_liplib__no_esd_guarded_pad_70x100.sym} 7620 -4340 2 0 {name=x16}
C {gf180mcu_liplib__no_esd_guarded_pad_70x100.sym} 7620 -4780 2 0 {name=x18}
C {gf180mcu_liplib__no_esd_guarded_pad_70x100.sym} 7620 -5220 2 0 {name=x21}
C {gf180mcu_liplib__no_esd_guarded_pad_70x100.sym} 7620 -5660 2 0 {name=x23}
C {gf180mcu_liplib__no_esd_guarded_pad_70x100.sym} 7620 -6100 2 0 {name=x25}
C {gf180mcu_liplib__no_esd_guarded_pad_70x100.sym} 7620 -6540 2 0 {name=x29}
C {fill_25.sym} 7620 -1480 2 0 {name=x31}
C {fill_25.sym} 7620 -6760 2 0 {name=x65}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 7630 -2360 2 0 {name=x7[0..1]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 7630 -2800 2 0 {name=x15[0..1]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 7630 -3240 2 0 {name=x17[0..1]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 7630 -3680 2 0 {name=x18[0..1]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 7630 -4120 2 0 {name=x19[0..1]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 7630 -4560 2 0 {name=x20[0..1]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 7630 -5000 2 0 {name=x21[0..1]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 7630 -5440 2 0 {name=x22[0..1]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 7630 -5880 2 0 {name=x23[0..1]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 7630 -6320 2 0 {name=x24[0..1]}
C {iopin.sym} 2140 -820 2 0 {name=p18 lab=VDD}
C {iopin.sym} 2140 -380 2 0 {name=p19 lab=VSS}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 7630 -16660 2 0 {name=x138}
C {iopin.sym} 7820 -16660 0 0 {name=p90 lab=TOFILL51_PAD}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 7630 -16220 2 0 {name=x139}
C {iopin.sym} 7820 -16220 0 0 {name=p91 lab=TOFILL50_PAD}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 7630 -8080 2 0 {name=x25[0..2]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 7630 -10280 2 0 {name=x40[0..2]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 7630 -10720 2 0 {name=x41[0..2]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 7630 -11160 2 0 {name=x42[0..2]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 7630 -11600 2 0 {name=x43[0..2]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 7630 -12040 2 0 {name=x44[0..2]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 7630 -12480 2 0 {name=x45[0..2]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 7630 -12920 2 0 {name=x46[0..2]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 7630 -13360 2 0 {name=x47[0..2]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 7630 -13800 2 0 {name=x48[0..2]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 7630 -14240 2 0 {name=x49[0..2]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 7630 -14680 2 0 {name=x50[0..2]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 7630 -15120 2 0 {name=x51[0..2]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 7630 -15560 2 0 {name=x52[0..2]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 7630 -16000 2 0 {name=x53[0..2]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 7630 -16440 2 0 {name=x54[0..2]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 7630 -16880 2 0 {name=x55[0..2]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 2360 -16900 0 0 {name=x58[0..2]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 2360 -16020 0 0 {name=x61[0..1]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 2360 -15140 0 0 {name=x62[0..2]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 2360 -14700 0 0 {name=x63[0..2]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 2360 -14260 0 0 {name=x64[0..2]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 2360 -13820 0 0 {name=x65[0..2]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 2360 -13380 0 0 {name=x66[0..2]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 2360 -12940 0 0 {name=x67[0..2]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 2360 -12500 0 0 {name=x68[0..2]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 2360 -12060 0 0 {name=x69[0..2]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 2360 -11620 0 0 {name=x70[0..2]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 2360 -11180 0 0 {name=x71[0..2]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 2360 -10740 0 0 {name=x72[0..2]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 2360 -8100 0 0 {name=x78[0..2]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 2360 -7660 0 0 {name=x79[0..2]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 2360 -7220 0 0 {name=x80[0..2]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 2360 -6780 0 0 {name=x81[0..2]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 2360 -6340 0 0 {name=x82[0..2]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 2360 -5900 0 0 {name=x83[0..2]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 2360 -5460 0 0 {name=x84[0..2]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 2360 -5020 0 0 {name=x85[0..2]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 2360 -4580 0 0 {name=x86[0..2]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 2360 -4140 0 0 {name=x87[0..2]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 2360 -3700 0 0 {name=x88[0..2]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 2360 -1500 0 0 {name=x89[0..2]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 2360 -1060 0 0 {name=x93[0..2]}
C {lv_nfet_W075L070.sym} 7140 -2320 3 0 {name=x8}
C {lv_pfet_W075L070.sym} 7140 -3620 3 0 {name=x15}
C {hv_nfet_W075L070.sym} 7140 -4940 3 0 {name=x27}
C {hv_pfet_W075L070.sym} 7140 -6260 3 0 {name=x33}
C {iopin.sym} 7840 -9620 0 0 {name=p15 lab=ESD_DIODES_FOUNDRY_VDD_CATHODE_PAD}
C {iopin.sym} 7840 -8740 0 0 {name=p92 lab=ESD_DIODES_FOUNDRY_VDD_ANODE_PAD}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 7630 -8300 2 0 {name=x143}
C {iopin.sym} 7840 -8300 0 0 {name=p93 lab=ESD_DIODES_GUARD_PAD}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 7630 -8960 2 0 {name=x95[0..1]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 7630 -9400 2 0 {name=x96[0..1]}
C {gf180mcu_liplib__no_esd_guarded_pad_70x100.sym} 7620 -8740 2 0 {name=x144}
C {gf180mcu_liplib__no_esd_guarded_pad_70x100.sym} 7620 -9180 2 0 {name=x145}
C {gf180mcu_liplib__no_esd_guarded_pad_70x100.sym} 7620 -9620 2 0 {name=x146}
C {iopin.sym} 7840 -9180 0 0 {name=p94 lab=ESD_DIODES_FOUNDRY_VSS_PAD}
C {symbols/diode_nd2ps_06v0.sym} 7220 -9150 2 0 {name=D1
model=diode_nd2ps_06v0
r_w=30u
r_l=50u
m=4}
C {symbols/diode_pd2nw_06v0.sym} 7040 -9110 2 0 {name=D2
model=diode_pd2nw_06v0
r_w=3u
r_l=50u
m=4}
C {fill_25.sym} 7620 -8520 2 0 {name=x126}
C {fill_25.sym} 7620 -9840 2 0 {name=x127}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 2360 -9860 0 0 {name=x73[0..1]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 2360 -9420 0 0 {name=x74[0..1]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 2360 -8980 0 0 {name=x75[0..1]}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 2360 -10520 0 0 {name=x66}
C {iopin.sym} 2150 -10520 2 0 {name=p20 lab=CAPACITORS_MIM_GUARD2_PAD}
C {symbols/cap_mim_2f0fF.sym} 2910 -9910 2 0 {name=C2
W=64e-6
L=64e-6
model=cap_mim_2f0fF
spiceprefix=X
m=1}
C {gf180mcu_liplib__no_esd_guarded_pad_70x100.sym} 2370 -9200 0 0 {name=x67}
C {iopin.sym} 2150 -9200 2 0 {name=p24 lab=CAPACITORS_MIM_2p0FF_8192FF_MAX_PERIM_1_PAD}
C {iopin.sym} 2150 -8760 2 0 {name=p25 lab=CAPACITORS_MIM_2p0FF_8192FF_MAX_PERIM_2_PAD}
C {gf180mcu_liplib__no_esd_guarded_pad_70x100.sym} 2370 -8760 0 0 {name=x68}
C {symbols/cap_mim_2f0fF.sym} 2950 -9050 2 0 {name=C1
W=16e-6
L=256e-6
model=cap_mim_2f0fF
spiceprefix=X
m=1}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 2360 -8320 0 0 {name=x69}
C {iopin.sym} 2150 -8320 2 0 {name=p51 lab=CAPACITORS_MIM_GUARD1_PAD}
C {iopin.sym} 2150 -9640 2 0 {name=p52 lab=CAPACITORS_MIM_2p0FF_8192FF_2_PAD}
C {gf180mcu_liplib__no_esd_guarded_pad_70x100.sym} 2370 -9640 0 0 {name=x74}
C {iopin.sym} 2150 -10080 2 0 {name=p95 lab=CAPACITORS_MIM_2p0FF_8192FF_1_PAD}
C {gf180mcu_liplib__no_esd_guarded_pad_70x100.sym} 2370 -10080 0 0 {name=x152}
C {fill_25.sym} 2370 -8540 0 0 {name=x153}
C {fill_25.sym} 2370 -10300 0 0 {name=x154}
C {gf180mcu_fd_io__dvss_70x100.sym} 7630 -17540 2 0 {name=x75}
C {gf180mcu_fd_io__dvdd_70x100.sym} 7630 -17100 2 0 {name=x128}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 7630 -17320 2 0 {name=x26[0..2]}
C {corner.sym} 7280 -17970 1 0 {name=x10}
C {iopin.sym} 7060 -18190 3 0 {name=p29 lab=PAD_ESD_TEST_GUARD_PAD}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 7060 -17980 1 0 {name=x20}
C {iopin.sym} 5740 -18190 3 0 {name=p30 lab=PAD_ESD_ASIG_GUARD_OUT_PAD}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 5740 -17980 1 0 {name=x14}
C {iopin.sym} 6400 -18190 3 0 {name=p27 lab=PAD_ESD_ASIG_GUARD_IN_PAD}
C {gf180mcu_liplib__asig_guard_5p0_pad_70x100.sym} 6400 -17980 1 0 {name=x28}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill1.sym} 6620 -17980 1 0 {name=x28[0..1]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 6840 -17980 1 0 {name=x29[0..9]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill1.sym} 5960 -17980 1 0 {name=x31[0..1]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 6180 -17980 1 0 {name=x32[0..9]}
C {hv_inverter_W075L070.sym} 6400 -17530 1 0 {name=x7}
C {gf180mcu_fd_io__dvss_70x100.sym} 2360 -17140 0 0 {name=x12}
C {gf180mcu_fd_io__dvdd_70x100.sym} 2360 -17580 0 0 {name=x17}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 2360 -17360 0 0 {name=x27[0..2]}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 3880 -17980 1 0 {name=x24}
C {iopin.sym} 3440 -18190 3 0 {name=p33 lab=PAD_ESD_GUARDSENSE_ASIG_OUT_PAD}
C {gf180mcu_fd_io__asig_5p0_70x100.sym} 3440 -17980 1 0 {name=x26}
C {corner.sym} 2780 -17970 1 0 {name=x105}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 3660 -17980 1 0 {name=x35[0..2]}
C {iopin.sym} 4860 -18190 3 0 {name=p28 lab=PAD_ESD_GUARDSENSE_ASIG_IN_PAD}
C {iopin.sym} 4760 -18190 3 0 {name=p31 lab=PAD_ESD_GUARDSENSE_SENSE_IN_PAD}
C {gf180mcu_liplib__asig_guard_sense_5p0_pad_70x100_p105.sym} 4810 -17970 1 0 {name=x22}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 4100 -17980 1 0 {name=x103[0..1]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill1.sym} 4540 -17980 1 0 {name=x30[0..1]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 5080 -17980 1 0 {name=x34[0..1]}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill1.sym} 5520 -17980 1 0 {name=x33[0..1]}
C {hv_inverter_W075L070.sym} 4960 -17240 1 0 {name=x134}
C {hv_inverter_W075L070.sym} 4670 -17420 1 0 {name=x147}
C {iopin.sym} 3880 -18190 3 0 {name=p32 lab=PAD_ESD_GUARDSENSE_SENSE_OUT_PAD}
C {lab_pin.sym} 4760 -17620 0 0 {name=p17 sig_type=std_logic lab=SENSE_RES_DEBUG}
C {lab_pin.sym} 4810 -17580 2 0 {name=p34 sig_type=std_logic lab=PAD_RES_DEBUG}
C {gf180mcu_liplib__no_esd_guarded_pad_70x100.sym} 2370 -16240 0 0 {name=x19}
C {iopin.sym} 2140 -14920 2 0 {name=p35 lab=GUARD_IMPORTANCE_TOP_GUARD_PAD

}
C {/foss/pdks/gf180mcuD/libs.ref/gf180mcu_fd_io/xschem/gf180mcu_fd_io__fill10.sym} 2360 -16460 0 0 {name=x36[0..1]}
